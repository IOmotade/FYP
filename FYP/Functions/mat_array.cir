*mat_array.cir

*Row Voltage Sources
V1 RowC_1 0 -5.000000
V3 RowC_2 0 -5.000000
V6 RowC_3 0 -5.000000
V10 RowC_4 0 -5.000000

*Row Current Sources
I1 I_1 0 -0.000000
I3 I_3 0 -0.000000
I6 I_6 0 -0.000000
I10 I_10 0 -0.000000

*Row 'Ammeter' Resistances
R41 RowC_1 MemRRow4 0.000000001000
R42 RowC_2 MemRRow7 0.000000001000
R43 RowC_3 MemRRow11 0.000000001000
R44 RowC_4 MemRRow16 0.000000001000

*Memristor Resistances
R14 MemRRow4 MemRCol4 398.107171
R18 MemRRow8 MemRCol8 630.957344
R113 MemRRow13 MemRCol13 158.489319
R119 MemRRow19 MemRCol19 39.810717
R17 MemRRow7 MemRCol7 2511.886432
R112 MemRRow12 MemRCol12 6309.573445
R118 MemRRow18 MemRCol18 3981.071706
R125 MemRRow25 MemRCol25 63.095734
R111 MemRRow11 MemRCol11 63.095734
R117 MemRRow17 MemRCol17 63.095734
R124 MemRRow24 MemRCol24 398.107171
R132 MemRRow32 MemRCol32 25.118864
R116 MemRRow16 MemRCol16 398.107171
R123 MemRRow23 MemRCol23 25.118864
R131 MemRRow31 MemRCol31 251.188643
R140 MemRRow40 MemRCol40 10000.000000

*Line Row Resistances
R24 MemRRow4 MemRRow8 10000.000000
R28 MemRRow8 MemRRow13 10000.000000
R213 MemRRow13 MemRRow19 10000.000000
R219 MemRRow19 MemRRow26 10000.000000
R27 MemRRow7 MemRRow12 10000.000000
R212 MemRRow12 MemRRow18 10000.000000
R218 MemRRow18 MemRRow25 10000.000000
R225 MemRRow25 MemRRow33 10000.000000
R211 MemRRow11 MemRRow17 10000.000000
R217 MemRRow17 MemRRow24 10000.000000
R224 MemRRow24 MemRRow32 10000.000000
R232 MemRRow32 MemRRow41 10000.000000
R216 MemRRow16 MemRRow23 10000.000000
R223 MemRRow23 MemRRow31 10000.000000
R231 MemRRow31 MemRRow40 10000.000000
R240 MemRRow40 MemRRow50 10000.000000

*Line Column Resistances
R34 MemRCol4 MemRCol7 10000.000000
R38 MemRCol8 MemRCol12 10000.000000
R313 MemRCol13 MemRCol18 10000.000000
R319 MemRCol19 MemRCol25 10000.000000
R37 MemRCol7 MemRCol11 10000.000000
R312 MemRCol12 MemRCol17 10000.000000
R318 MemRCol18 MemRCol24 10000.000000
R325 MemRCol25 MemRCol32 10000.000000
R311 MemRCol11 MemRCol16 10000.000000
R317 MemRCol17 MemRCol23 10000.000000
R324 MemRCol24 MemRCol31 10000.000000
R332 MemRCol32 MemRCol40 10000.000000
R316 MemRCol16 MemRCol22 10000.000000
R323 MemRCol23 MemRCol30 10000.000000
R331 MemRCol31 MemRCol39 10000.000000
R340 MemRCol40 MemRCol49 10000.000000

*Column 'Ammeter' Resistances
R51 MemRCol22 ColC_1 0.000000001000
R52 MemRCol30 ColC_2 0.000000001000
R53 MemRCol39 ColC_3 0.000000001000
R54 MemRCol49 ColC_4 0.000000001000

*Column Voltage Sources
V2 ColC_1 0 0.000000
V5 ColC_2 0 0.000000
V9 ColC_3 0 0.000000
V14 ColC_4 0 0.000000

*Column Current Sources
I2 I_2 0 -0.000000
I5 I_5 0 -0.000000
I9 I_9 0 -0.000000
I14 I_14 0 -0.000000

*Spice Directives
.op
*.backanno
.end
