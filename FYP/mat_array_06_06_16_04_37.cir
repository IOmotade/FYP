*mat_array_06_06_16_04_37.cir

*Row Voltage Sources
V1 RowC_1 0 11.854907
V3 RowC_2 0 3.998867
V6 RowC_3 0 6.002865
V10 RowC_4 0 2.451697
V15 RowC_5 0 0.941166
V21 RowC_6 0 2.116311
V28 RowC_7 0 -6.886658
V36 RowC_8 0 -6.066282

*Row Current Sources
I1 I_1 0 -0.000000
I3 I_3 0 -0.000000
I6 I_6 0 -0.000000
I10 I_10 0 -0.000000
I15 I_15 0 -0.000000
I21 I_21 0 -0.000000
I28 I_28 0 -0.000000
I36 I_36 0 -0.000000

*Row 'Ammeter' Resistances
R41 RowC_1 MemRRow4 0.000000001000
R42 RowC_2 MemRRow7 0.000000001000
R43 RowC_3 MemRRow11 0.000000001000
R44 RowC_4 MemRRow16 0.000000001000
R45 RowC_5 MemRRow22 0.000000001000
R46 RowC_6 MemRRow29 0.000000001000
R47 RowC_7 MemRRow37 0.000000001000
R48 RowC_8 MemRRow46 0.000000001000

*Memristor Resistances
R14 MemRRow4 MemRCol4 733360.000000
R18 MemRRow8 MemRCol8 666700.000000
R113 MemRRow13 MemRCol13 733360.000000
R119 MemRRow19 MemRCol19 733360.000000
R126 MemRRow26 MemRCol26 933340.000000
R134 MemRRow34 MemRCol34 600040.000000
R143 MemRRow43 MemRCol43 200080.000000
R153 MemRRow53 MemRCol53 333400.000000
R17 MemRRow7 MemRCol7 400060.000000
R112 MemRRow12 MemRCol12 533380.000000
R118 MemRRow18 MemRCol18 533380.000000
R125 MemRRow25 MemRCol25 66760.000000
R133 MemRRow33 MemRCol33 66760.000000
R142 MemRRow42 MemRCol42 800020.000000
R152 MemRRow52 MemRCol52 200080.000000
R163 MemRRow63 MemRCol63 866680.000000
R111 MemRRow11 MemRCol11 1000000.000000
R117 MemRRow17 MemRCol17 100.000000
R124 MemRRow24 MemRCol24 600040.000000
R132 MemRRow32 MemRCol32 600040.000000
R141 MemRRow41 MemRCol41 666700.000000
R151 MemRRow51 MemRCol51 200080.000000
R162 MemRRow62 MemRCol62 533380.000000
R174 MemRRow74 MemRCol74 333400.000000
R116 MemRRow16 MemRCol16 866680.000000
R123 MemRRow23 MemRCol23 600040.000000
R131 MemRRow31 MemRCol31 600040.000000
R140 MemRRow40 MemRCol40 333400.000000
R150 MemRRow50 MemRCol50 533380.000000
R161 MemRRow61 MemRCol61 800020.000000
R173 MemRRow73 MemRCol73 1000000.000000
R186 MemRRow86 MemRCol86 133420.000000
R122 MemRRow22 MemRCol22 733360.000000
R130 MemRRow30 MemRCol30 266740.000000
R139 MemRRow39 MemRCol39 800020.000000
R149 MemRRow49 MemRCol49 733360.000000
R160 MemRRow60 MemRCol60 133420.000000
R172 MemRRow72 MemRCol72 133420.000000
R185 MemRRow85 MemRCol85 933340.000000
R199 MemRRow99 MemRCol99 933340.000000
R129 MemRRow29 MemRCol29 733360.000000
R138 MemRRow38 MemRCol38 666700.000000
R148 MemRRow48 MemRCol48 466720.000000
R159 MemRRow59 MemRCol59 1000000.000000
R171 MemRRow71 MemRCol71 533380.000000
R184 MemRRow84 MemRCol84 733360.000000
R198 MemRRow98 MemRCol98 266740.000000
R1113 MemRRow113 MemRCol113 733360.000000
R137 MemRRow37 MemRCol37 400060.000000
R147 MemRRow47 MemRCol47 600040.000000
R158 MemRRow58 MemRCol58 66760.000000
R170 MemRRow70 MemRCol70 1000000.000000
R183 MemRRow83 MemRCol83 1000000.000000
R197 MemRRow97 MemRCol97 333400.000000
R1112 MemRRow112 MemRCol112 600040.000000
R1128 MemRRow128 MemRCol128 800020.000000
R146 MemRRow46 MemRCol46 933340.000000
R157 MemRRow57 MemRCol57 533380.000000
R169 MemRRow69 MemRCol69 400060.000000
R182 MemRRow82 MemRCol82 400060.000000
R196 MemRRow96 MemRCol96 466720.000000
R1111 MemRRow111 MemRCol111 733360.000000
R1127 MemRRow127 MemRCol127 133420.000000
R1144 MemRRow144 MemRCol144 933340.000000

*Line Row Resistances
R24 MemRRow4 MemRRow8 10000.000000
R28 MemRRow8 MemRRow13 10000.000000
R213 MemRRow13 MemRRow19 10000.000000
R219 MemRRow19 MemRRow26 10000.000000
R226 MemRRow26 MemRRow34 10000.000000
R234 MemRRow34 MemRRow43 10000.000000
R243 MemRRow43 MemRRow53 10000.000000
R253 MemRRow53 MemRRow64 10000.000000
R27 MemRRow7 MemRRow12 10000.000000
R212 MemRRow12 MemRRow18 10000.000000
R218 MemRRow18 MemRRow25 10000.000000
R225 MemRRow25 MemRRow33 10000.000000
R233 MemRRow33 MemRRow42 10000.000000
R242 MemRRow42 MemRRow52 10000.000000
R252 MemRRow52 MemRRow63 10000.000000
R263 MemRRow63 MemRRow75 10000.000000
R211 MemRRow11 MemRRow17 10000.000000
R217 MemRRow17 MemRRow24 10000.000000
R224 MemRRow24 MemRRow32 10000.000000
R232 MemRRow32 MemRRow41 10000.000000
R241 MemRRow41 MemRRow51 10000.000000
R251 MemRRow51 MemRRow62 10000.000000
R262 MemRRow62 MemRRow74 10000.000000
R274 MemRRow74 MemRRow87 10000.000000
R216 MemRRow16 MemRRow23 10000.000000
R223 MemRRow23 MemRRow31 10000.000000
R231 MemRRow31 MemRRow40 10000.000000
R240 MemRRow40 MemRRow50 10000.000000
R250 MemRRow50 MemRRow61 10000.000000
R261 MemRRow61 MemRRow73 10000.000000
R273 MemRRow73 MemRRow86 10000.000000
R286 MemRRow86 MemRRow100 10000.000000
R222 MemRRow22 MemRRow30 10000.000000
R230 MemRRow30 MemRRow39 10000.000000
R239 MemRRow39 MemRRow49 10000.000000
R249 MemRRow49 MemRRow60 10000.000000
R260 MemRRow60 MemRRow72 10000.000000
R272 MemRRow72 MemRRow85 10000.000000
R285 MemRRow85 MemRRow99 10000.000000
R299 MemRRow99 MemRRow114 10000.000000
R229 MemRRow29 MemRRow38 10000.000000
R238 MemRRow38 MemRRow48 10000.000000
R248 MemRRow48 MemRRow59 10000.000000
R259 MemRRow59 MemRRow71 10000.000000
R271 MemRRow71 MemRRow84 10000.000000
R284 MemRRow84 MemRRow98 10000.000000
R298 MemRRow98 MemRRow113 10000.000000
R2113 MemRRow113 MemRRow129 10000.000000
R237 MemRRow37 MemRRow47 10000.000000
R247 MemRRow47 MemRRow58 10000.000000
R258 MemRRow58 MemRRow70 10000.000000
R270 MemRRow70 MemRRow83 10000.000000
R283 MemRRow83 MemRRow97 10000.000000
R297 MemRRow97 MemRRow112 10000.000000
R2112 MemRRow112 MemRRow128 10000.000000
R2128 MemRRow128 MemRRow145 10000.000000
R246 MemRRow46 MemRRow57 10000.000000
R257 MemRRow57 MemRRow69 10000.000000
R269 MemRRow69 MemRRow82 10000.000000
R282 MemRRow82 MemRRow96 10000.000000
R296 MemRRow96 MemRRow111 10000.000000
R2111 MemRRow111 MemRRow127 10000.000000
R2127 MemRRow127 MemRRow144 10000.000000
R2144 MemRRow144 MemRRow162 10000.000000

*Line Column Resistances
R34 MemRCol4 MemRCol7 10000.000000
R38 MemRCol8 MemRCol12 10000.000000
R313 MemRCol13 MemRCol18 10000.000000
R319 MemRCol19 MemRCol25 10000.000000
R326 MemRCol26 MemRCol33 10000.000000
R334 MemRCol34 MemRCol42 10000.000000
R343 MemRCol43 MemRCol52 10000.000000
R353 MemRCol53 MemRCol63 10000.000000
R37 MemRCol7 MemRCol11 10000.000000
R312 MemRCol12 MemRCol17 10000.000000
R318 MemRCol18 MemRCol24 10000.000000
R325 MemRCol25 MemRCol32 10000.000000
R333 MemRCol33 MemRCol41 10000.000000
R342 MemRCol42 MemRCol51 10000.000000
R352 MemRCol52 MemRCol62 10000.000000
R363 MemRCol63 MemRCol74 10000.000000
R311 MemRCol11 MemRCol16 10000.000000
R317 MemRCol17 MemRCol23 10000.000000
R324 MemRCol24 MemRCol31 10000.000000
R332 MemRCol32 MemRCol40 10000.000000
R341 MemRCol41 MemRCol50 10000.000000
R351 MemRCol51 MemRCol61 10000.000000
R362 MemRCol62 MemRCol73 10000.000000
R374 MemRCol74 MemRCol86 10000.000000
R316 MemRCol16 MemRCol22 10000.000000
R323 MemRCol23 MemRCol30 10000.000000
R331 MemRCol31 MemRCol39 10000.000000
R340 MemRCol40 MemRCol49 10000.000000
R350 MemRCol50 MemRCol60 10000.000000
R361 MemRCol61 MemRCol72 10000.000000
R373 MemRCol73 MemRCol85 10000.000000
R386 MemRCol86 MemRCol99 10000.000000
R322 MemRCol22 MemRCol29 10000.000000
R330 MemRCol30 MemRCol38 10000.000000
R339 MemRCol39 MemRCol48 10000.000000
R349 MemRCol49 MemRCol59 10000.000000
R360 MemRCol60 MemRCol71 10000.000000
R372 MemRCol72 MemRCol84 10000.000000
R385 MemRCol85 MemRCol98 10000.000000
R399 MemRCol99 MemRCol113 10000.000000
R329 MemRCol29 MemRCol37 10000.000000
R338 MemRCol38 MemRCol47 10000.000000
R348 MemRCol48 MemRCol58 10000.000000
R359 MemRCol59 MemRCol70 10000.000000
R371 MemRCol71 MemRCol83 10000.000000
R384 MemRCol84 MemRCol97 10000.000000
R398 MemRCol98 MemRCol112 10000.000000
R3113 MemRCol113 MemRCol128 10000.000000
R337 MemRCol37 MemRCol46 10000.000000
R347 MemRCol47 MemRCol57 10000.000000
R358 MemRCol58 MemRCol69 10000.000000
R370 MemRCol70 MemRCol82 10000.000000
R383 MemRCol83 MemRCol96 10000.000000
R397 MemRCol97 MemRCol111 10000.000000
R3112 MemRCol112 MemRCol127 10000.000000
R3128 MemRCol128 MemRCol144 10000.000000
R346 MemRCol46 MemRCol56 10000.000000
R357 MemRCol57 MemRCol68 10000.000000
R369 MemRCol69 MemRCol81 10000.000000
R382 MemRCol82 MemRCol95 10000.000000
R396 MemRCol96 MemRCol110 10000.000000
R3111 MemRCol111 MemRCol126 10000.000000
R3127 MemRCol127 MemRCol143 10000.000000
R3144 MemRCol144 MemRCol161 10000.000000

*Column 'Ammeter' Resistances
R51 MemRCol56 ColC_1 0.000000001000
R52 MemRCol68 ColC_2 0.000000001000
R53 MemRCol81 ColC_3 0.000000001000
R54 MemRCol95 ColC_4 0.000000001000
R55 MemRCol110 ColC_5 0.000000001000
R56 MemRCol126 ColC_6 0.000000001000
R57 MemRCol143 ColC_7 0.000000001000
R58 MemRCol161 ColC_8 0.000000001000

*Column Voltage Sources
V2 ColC_1 0 0.000000
V5 ColC_2 0 0.000000
V9 ColC_3 0 0.000000
V14 ColC_4 0 0.000000
V20 ColC_5 0 0.000000
V27 ColC_6 0 0.000000
V35 ColC_7 0 0.000000
V44 ColC_8 0 0.000000

*Column Current Sources
I2 I_2 0 -0.000000
I5 I_5 0 -0.000000
I9 I_9 0 -0.000000
I14 I_14 0 -0.000000
I20 I_20 0 -0.000000
I27 I_27 0 -0.000000
I35 I_35 0 -0.000000
I44 I_44 0 -0.000000

*Spice Directives
.op
*.backanno
.end
