*mat_array.cir

*Voltage Sources
V1 V_1 0 5.000000
V2 V_2 0 5.000000
V3 V_3 0 5.000000
V4 V_4 0 5.000000
V5 V_5 0 5.000000
V6 V_6 0 5.000000
V7 V_7 0 5.000000
V8 V_8 0 5.000000
V9 V_9 0 5.000000
V10 V_10 0 5.000000
V11 V_11 0 5.000000
V12 V_12 0 5.000000
V13 V_13 0 5.000000
V14 V_14 0 5.000000
V15 V_15 0 5.000000
V16 V_16 0 5.000000
V17 V_17 0 5.000000
V18 V_18 0 5.000000
V19 V_19 0 5.000000
V20 V_20 0 5.000000
V21 V_21 0 5.000000
V22 V_22 0 5.000000
V23 V_23 0 5.000000
V24 V_24 0 5.000000
V25 V_25 0 5.000000
V26 V_26 0 5.000000
V27 V_27 0 5.000000
V28 V_28 0 5.000000
V29 V_29 0 5.000000
V30 V_30 0 5.000000
V31 V_31 0 5.000000
V32 V_32 0 5.000000
V33 V_33 0 5.000000
V34 V_34 0 5.000000
V35 V_35 0 5.000000
V36 V_36 0 5.000000
V37 V_37 0 5.000000
V38 V_38 0 5.000000
V39 V_39 0 5.000000
V40 V_40 0 5.000000
V41 V_41 0 5.000000
V42 V_42 0 5.000000
V43 V_43 0 5.000000
V44 V_44 0 5.000000
V45 V_45 0 5.000000
V46 V_46 0 5.000000
V47 V_47 0 5.000000
V48 V_48 0 5.000000
V49 V_49 0 5.000000
V50 V_50 0 5.000000

*Row 'Ammeter' Resistances
R41 V_1 MemRRow4 0.000000001000
R42 V_2 MemRRow7 0.000000001000
R43 V_3 MemRRow11 0.000000001000
R44 V_4 MemRRow16 0.000000001000
R45 V_5 MemRRow22 0.000000001000
R46 V_6 MemRRow29 0.000000001000
R47 V_7 MemRRow37 0.000000001000
R48 V_8 MemRRow46 0.000000001000
R49 V_9 MemRRow56 0.000000001000
R410 V_10 MemRRow67 0.000000001000
R411 V_11 MemRRow79 0.000000001000
R412 V_12 MemRRow92 0.000000001000
R413 V_13 MemRRow106 0.000000001000
R414 V_14 MemRRow121 0.000000001000
R415 V_15 MemRRow137 0.000000001000
R416 V_16 MemRRow154 0.000000001000
R417 V_17 MemRRow172 0.000000001000
R418 V_18 MemRRow191 0.000000001000
R419 V_19 MemRRow211 0.000000001000
R420 V_20 MemRRow232 0.000000001000
R421 V_21 MemRRow254 0.000000001000
R422 V_22 MemRRow277 0.000000001000
R423 V_23 MemRRow301 0.000000001000
R424 V_24 MemRRow326 0.000000001000
R425 V_25 MemRRow352 0.000000001000
R426 V_26 MemRRow379 0.000000001000
R427 V_27 MemRRow407 0.000000001000
R428 V_28 MemRRow436 0.000000001000
R429 V_29 MemRRow466 0.000000001000
R430 V_30 MemRRow497 0.000000001000
R431 V_31 MemRRow529 0.000000001000
R432 V_32 MemRRow562 0.000000001000
R433 V_33 MemRRow596 0.000000001000
R434 V_34 MemRRow631 0.000000001000
R435 V_35 MemRRow667 0.000000001000
R436 V_36 MemRRow704 0.000000001000
R437 V_37 MemRRow742 0.000000001000
R438 V_38 MemRRow781 0.000000001000
R439 V_39 MemRRow821 0.000000001000
R440 V_40 MemRRow862 0.000000001000
R441 V_41 MemRRow904 0.000000001000
R442 V_42 MemRRow947 0.000000001000
R443 V_43 MemRRow991 0.000000001000
R444 V_44 MemRRow1036 0.000000001000
R445 V_45 MemRRow1082 0.000000001000
R446 V_46 MemRRow1129 0.000000001000
R447 V_47 MemRRow1177 0.000000001000
R448 V_48 MemRRow1226 0.000000001000
R449 V_49 MemRRow1276 0.000000001000
R450 V_50 MemRRow1327 0.000000001000

*Memristor Resistances
R14 MemRRow4 MemRCol4 10000.000000
R18 MemRRow8 MemRCol8 10000.000000
R113 MemRRow13 MemRCol13 10000.000000
R119 MemRRow19 MemRCol19 10000.000000
R126 MemRRow26 MemRCol26 10000.000000
R134 MemRRow34 MemRCol34 10000.000000
R143 MemRRow43 MemRCol43 10000.000000
R153 MemRRow53 MemRCol53 10000.000000
R164 MemRRow64 MemRCol64 10000.000000
R176 MemRRow76 MemRCol76 10000.000000
R189 MemRRow89 MemRCol89 10000.000000
R1103 MemRRow103 MemRCol103 10000.000000
R1118 MemRRow118 MemRCol118 10000.000000
R1134 MemRRow134 MemRCol134 10000.000000
R1151 MemRRow151 MemRCol151 10000.000000
R1169 MemRRow169 MemRCol169 10000.000000
R1188 MemRRow188 MemRCol188 10000.000000
R1208 MemRRow208 MemRCol208 10000.000000
R1229 MemRRow229 MemRCol229 10000.000000
R1251 MemRRow251 MemRCol251 10000.000000
R1274 MemRRow274 MemRCol274 10000.000000
R1298 MemRRow298 MemRCol298 10000.000000
R1323 MemRRow323 MemRCol323 10000.000000
R1349 MemRRow349 MemRCol349 10000.000000
R1376 MemRRow376 MemRCol376 10000.000000
R1404 MemRRow404 MemRCol404 10000.000000
R1433 MemRRow433 MemRCol433 10000.000000
R1463 MemRRow463 MemRCol463 10000.000000
R1494 MemRRow494 MemRCol494 10000.000000
R1526 MemRRow526 MemRCol526 10000.000000
R1559 MemRRow559 MemRCol559 10000.000000
R1593 MemRRow593 MemRCol593 10000.000000
R1628 MemRRow628 MemRCol628 10000.000000
R1664 MemRRow664 MemRCol664 10000.000000
R1701 MemRRow701 MemRCol701 10000.000000
R1739 MemRRow739 MemRCol739 10000.000000
R1778 MemRRow778 MemRCol778 10000.000000
R1818 MemRRow818 MemRCol818 10000.000000
R1859 MemRRow859 MemRCol859 10000.000000
R1901 MemRRow901 MemRCol901 10000.000000
R1944 MemRRow944 MemRCol944 10000.000000
R1988 MemRRow988 MemRCol988 10000.000000
R11033 MemRRow1033 MemRCol1033 10000.000000
R11079 MemRRow1079 MemRCol1079 10000.000000
R11126 MemRRow1126 MemRCol1126 10000.000000
R11174 MemRRow1174 MemRCol1174 10000.000000
R11223 MemRRow1223 MemRCol1223 10000.000000
R11273 MemRRow1273 MemRCol1273 10000.000000
R11324 MemRRow1324 MemRCol1324 10000.000000
R11376 MemRRow1376 MemRCol1376 10000.000000
R17 MemRRow7 MemRCol7 10000.000000
R112 MemRRow12 MemRCol12 10000.000000
R118 MemRRow18 MemRCol18 10000.000000
R125 MemRRow25 MemRCol25 10000.000000
R133 MemRRow33 MemRCol33 10000.000000
R142 MemRRow42 MemRCol42 10000.000000
R152 MemRRow52 MemRCol52 10000.000000
R163 MemRRow63 MemRCol63 10000.000000
R175 MemRRow75 MemRCol75 10000.000000
R188 MemRRow88 MemRCol88 10000.000000
R1102 MemRRow102 MemRCol102 10000.000000
R1117 MemRRow117 MemRCol117 10000.000000
R1133 MemRRow133 MemRCol133 10000.000000
R1150 MemRRow150 MemRCol150 10000.000000
R1168 MemRRow168 MemRCol168 10000.000000
R1187 MemRRow187 MemRCol187 10000.000000
R1207 MemRRow207 MemRCol207 10000.000000
R1228 MemRRow228 MemRCol228 10000.000000
R1250 MemRRow250 MemRCol250 10000.000000
R1273 MemRRow273 MemRCol273 10000.000000
R1297 MemRRow297 MemRCol297 10000.000000
R1322 MemRRow322 MemRCol322 10000.000000
R1348 MemRRow348 MemRCol348 10000.000000
R1375 MemRRow375 MemRCol375 10000.000000
R1403 MemRRow403 MemRCol403 10000.000000
R1432 MemRRow432 MemRCol432 10000.000000
R1462 MemRRow462 MemRCol462 10000.000000
R1493 MemRRow493 MemRCol493 10000.000000
R1525 MemRRow525 MemRCol525 10000.000000
R1558 MemRRow558 MemRCol558 10000.000000
R1592 MemRRow592 MemRCol592 10000.000000
R1627 MemRRow627 MemRCol627 10000.000000
R1663 MemRRow663 MemRCol663 10000.000000
R1700 MemRRow700 MemRCol700 10000.000000
R1738 MemRRow738 MemRCol738 10000.000000
R1777 MemRRow777 MemRCol777 10000.000000
R1817 MemRRow817 MemRCol817 10000.000000
R1858 MemRRow858 MemRCol858 10000.000000
R1900 MemRRow900 MemRCol900 10000.000000
R1943 MemRRow943 MemRCol943 10000.000000
R1987 MemRRow987 MemRCol987 10000.000000
R11032 MemRRow1032 MemRCol1032 10000.000000
R11078 MemRRow1078 MemRCol1078 10000.000000
R11125 MemRRow1125 MemRCol1125 10000.000000
R11173 MemRRow1173 MemRCol1173 10000.000000
R11222 MemRRow1222 MemRCol1222 10000.000000
R11272 MemRRow1272 MemRCol1272 10000.000000
R11323 MemRRow1323 MemRCol1323 10000.000000
R11375 MemRRow1375 MemRCol1375 10000.000000
R11428 MemRRow1428 MemRCol1428 10000.000000
R111 MemRRow11 MemRCol11 10000.000000
R117 MemRRow17 MemRCol17 10000.000000
R124 MemRRow24 MemRCol24 10000.000000
R132 MemRRow32 MemRCol32 10000.000000
R141 MemRRow41 MemRCol41 10000.000000
R151 MemRRow51 MemRCol51 10000.000000
R162 MemRRow62 MemRCol62 10000.000000
R174 MemRRow74 MemRCol74 10000.000000
R187 MemRRow87 MemRCol87 10000.000000
R1101 MemRRow101 MemRCol101 10000.000000
R1116 MemRRow116 MemRCol116 10000.000000
R1132 MemRRow132 MemRCol132 10000.000000
R1149 MemRRow149 MemRCol149 10000.000000
R1167 MemRRow167 MemRCol167 10000.000000
R1186 MemRRow186 MemRCol186 10000.000000
R1206 MemRRow206 MemRCol206 10000.000000
R1227 MemRRow227 MemRCol227 10000.000000
R1249 MemRRow249 MemRCol249 10000.000000
R1272 MemRRow272 MemRCol272 10000.000000
R1296 MemRRow296 MemRCol296 10000.000000
R1321 MemRRow321 MemRCol321 10000.000000
R1347 MemRRow347 MemRCol347 10000.000000
R1374 MemRRow374 MemRCol374 10000.000000
R1402 MemRRow402 MemRCol402 10000.000000
R1431 MemRRow431 MemRCol431 10000.000000
R1461 MemRRow461 MemRCol461 10000.000000
R1492 MemRRow492 MemRCol492 10000.000000
R1524 MemRRow524 MemRCol524 10000.000000
R1557 MemRRow557 MemRCol557 10000.000000
R1591 MemRRow591 MemRCol591 10000.000000
R1626 MemRRow626 MemRCol626 10000.000000
R1662 MemRRow662 MemRCol662 10000.000000
R1699 MemRRow699 MemRCol699 10000.000000
R1737 MemRRow737 MemRCol737 10000.000000
R1776 MemRRow776 MemRCol776 10000.000000
R1816 MemRRow816 MemRCol816 10000.000000
R1857 MemRRow857 MemRCol857 10000.000000
R1899 MemRRow899 MemRCol899 10000.000000
R1942 MemRRow942 MemRCol942 10000.000000
R1986 MemRRow986 MemRCol986 10000.000000
R11031 MemRRow1031 MemRCol1031 10000.000000
R11077 MemRRow1077 MemRCol1077 10000.000000
R11124 MemRRow1124 MemRCol1124 10000.000000
R11172 MemRRow1172 MemRCol1172 10000.000000
R11221 MemRRow1221 MemRCol1221 10000.000000
R11271 MemRRow1271 MemRCol1271 10000.000000
R11322 MemRRow1322 MemRCol1322 10000.000000
R11374 MemRRow1374 MemRCol1374 10000.000000
R11427 MemRRow1427 MemRCol1427 10000.000000
R11481 MemRRow1481 MemRCol1481 10000.000000
R116 MemRRow16 MemRCol16 10000.000000
R123 MemRRow23 MemRCol23 10000.000000
R131 MemRRow31 MemRCol31 10000.000000
R140 MemRRow40 MemRCol40 10000.000000
R150 MemRRow50 MemRCol50 10000.000000
R161 MemRRow61 MemRCol61 10000.000000
R173 MemRRow73 MemRCol73 10000.000000
R186 MemRRow86 MemRCol86 10000.000000
R1100 MemRRow100 MemRCol100 10000.000000
R1115 MemRRow115 MemRCol115 10000.000000
R1131 MemRRow131 MemRCol131 10000.000000
R1148 MemRRow148 MemRCol148 10000.000000
R1166 MemRRow166 MemRCol166 10000.000000
R1185 MemRRow185 MemRCol185 10000.000000
R1205 MemRRow205 MemRCol205 10000.000000
R1226 MemRRow226 MemRCol226 10000.000000
R1248 MemRRow248 MemRCol248 10000.000000
R1271 MemRRow271 MemRCol271 10000.000000
R1295 MemRRow295 MemRCol295 10000.000000
R1320 MemRRow320 MemRCol320 10000.000000
R1346 MemRRow346 MemRCol346 10000.000000
R1373 MemRRow373 MemRCol373 10000.000000
R1401 MemRRow401 MemRCol401 10000.000000
R1430 MemRRow430 MemRCol430 10000.000000
R1460 MemRRow460 MemRCol460 10000.000000
R1491 MemRRow491 MemRCol491 10000.000000
R1523 MemRRow523 MemRCol523 10000.000000
R1556 MemRRow556 MemRCol556 10000.000000
R1590 MemRRow590 MemRCol590 10000.000000
R1625 MemRRow625 MemRCol625 10000.000000
R1661 MemRRow661 MemRCol661 10000.000000
R1698 MemRRow698 MemRCol698 10000.000000
R1736 MemRRow736 MemRCol736 10000.000000
R1775 MemRRow775 MemRCol775 10000.000000
R1815 MemRRow815 MemRCol815 10000.000000
R1856 MemRRow856 MemRCol856 10000.000000
R1898 MemRRow898 MemRCol898 10000.000000
R1941 MemRRow941 MemRCol941 10000.000000
R1985 MemRRow985 MemRCol985 10000.000000
R11030 MemRRow1030 MemRCol1030 10000.000000
R11076 MemRRow1076 MemRCol1076 10000.000000
R11123 MemRRow1123 MemRCol1123 10000.000000
R11171 MemRRow1171 MemRCol1171 10000.000000
R11220 MemRRow1220 MemRCol1220 10000.000000
R11270 MemRRow1270 MemRCol1270 10000.000000
R11321 MemRRow1321 MemRCol1321 10000.000000
R11373 MemRRow1373 MemRCol1373 10000.000000
R11426 MemRRow1426 MemRCol1426 10000.000000
R11480 MemRRow1480 MemRCol1480 10000.000000
R11535 MemRRow1535 MemRCol1535 10000.000000
R122 MemRRow22 MemRCol22 10000.000000
R130 MemRRow30 MemRCol30 10000.000000
R139 MemRRow39 MemRCol39 10000.000000
R149 MemRRow49 MemRCol49 10000.000000
R160 MemRRow60 MemRCol60 10000.000000
R172 MemRRow72 MemRCol72 10000.000000
R185 MemRRow85 MemRCol85 10000.000000
R199 MemRRow99 MemRCol99 10000.000000
R1114 MemRRow114 MemRCol114 10000.000000
R1130 MemRRow130 MemRCol130 10000.000000
R1147 MemRRow147 MemRCol147 10000.000000
R1165 MemRRow165 MemRCol165 10000.000000
R1184 MemRRow184 MemRCol184 10000.000000
R1204 MemRRow204 MemRCol204 10000.000000
R1225 MemRRow225 MemRCol225 10000.000000
R1247 MemRRow247 MemRCol247 10000.000000
R1270 MemRRow270 MemRCol270 10000.000000
R1294 MemRRow294 MemRCol294 10000.000000
R1319 MemRRow319 MemRCol319 10000.000000
R1345 MemRRow345 MemRCol345 10000.000000
R1372 MemRRow372 MemRCol372 10000.000000
R1400 MemRRow400 MemRCol400 10000.000000
R1429 MemRRow429 MemRCol429 10000.000000
R1459 MemRRow459 MemRCol459 10000.000000
R1490 MemRRow490 MemRCol490 10000.000000
R1522 MemRRow522 MemRCol522 10000.000000
R1555 MemRRow555 MemRCol555 10000.000000
R1589 MemRRow589 MemRCol589 10000.000000
R1624 MemRRow624 MemRCol624 10000.000000
R1660 MemRRow660 MemRCol660 10000.000000
R1697 MemRRow697 MemRCol697 10000.000000
R1735 MemRRow735 MemRCol735 10000.000000
R1774 MemRRow774 MemRCol774 10000.000000
R1814 MemRRow814 MemRCol814 10000.000000
R1855 MemRRow855 MemRCol855 10000.000000
R1897 MemRRow897 MemRCol897 10000.000000
R1940 MemRRow940 MemRCol940 10000.000000
R1984 MemRRow984 MemRCol984 10000.000000
R11029 MemRRow1029 MemRCol1029 10000.000000
R11075 MemRRow1075 MemRCol1075 10000.000000
R11122 MemRRow1122 MemRCol1122 10000.000000
R11170 MemRRow1170 MemRCol1170 10000.000000
R11219 MemRRow1219 MemRCol1219 10000.000000
R11269 MemRRow1269 MemRCol1269 10000.000000
R11320 MemRRow1320 MemRCol1320 10000.000000
R11372 MemRRow1372 MemRCol1372 10000.000000
R11425 MemRRow1425 MemRCol1425 10000.000000
R11479 MemRRow1479 MemRCol1479 10000.000000
R11534 MemRRow1534 MemRCol1534 10000.000000
R11590 MemRRow1590 MemRCol1590 10000.000000
R129 MemRRow29 MemRCol29 10000.000000
R138 MemRRow38 MemRCol38 10000.000000
R148 MemRRow48 MemRCol48 10000.000000
R159 MemRRow59 MemRCol59 10000.000000
R171 MemRRow71 MemRCol71 10000.000000
R184 MemRRow84 MemRCol84 10000.000000
R198 MemRRow98 MemRCol98 10000.000000
R1113 MemRRow113 MemRCol113 10000.000000
R1129 MemRRow129 MemRCol129 10000.000000
R1146 MemRRow146 MemRCol146 10000.000000
R1164 MemRRow164 MemRCol164 10000.000000
R1183 MemRRow183 MemRCol183 10000.000000
R1203 MemRRow203 MemRCol203 10000.000000
R1224 MemRRow224 MemRCol224 10000.000000
R1246 MemRRow246 MemRCol246 10000.000000
R1269 MemRRow269 MemRCol269 10000.000000
R1293 MemRRow293 MemRCol293 10000.000000
R1318 MemRRow318 MemRCol318 10000.000000
R1344 MemRRow344 MemRCol344 10000.000000
R1371 MemRRow371 MemRCol371 10000.000000
R1399 MemRRow399 MemRCol399 10000.000000
R1428 MemRRow428 MemRCol428 10000.000000
R1458 MemRRow458 MemRCol458 10000.000000
R1489 MemRRow489 MemRCol489 10000.000000
R1521 MemRRow521 MemRCol521 10000.000000
R1554 MemRRow554 MemRCol554 10000.000000
R1588 MemRRow588 MemRCol588 10000.000000
R1623 MemRRow623 MemRCol623 10000.000000
R1659 MemRRow659 MemRCol659 10000.000000
R1696 MemRRow696 MemRCol696 10000.000000
R1734 MemRRow734 MemRCol734 10000.000000
R1773 MemRRow773 MemRCol773 10000.000000
R1813 MemRRow813 MemRCol813 10000.000000
R1854 MemRRow854 MemRCol854 10000.000000
R1896 MemRRow896 MemRCol896 10000.000000
R1939 MemRRow939 MemRCol939 10000.000000
R1983 MemRRow983 MemRCol983 10000.000000
R11028 MemRRow1028 MemRCol1028 10000.000000
R11074 MemRRow1074 MemRCol1074 10000.000000
R11121 MemRRow1121 MemRCol1121 10000.000000
R11169 MemRRow1169 MemRCol1169 10000.000000
R11218 MemRRow1218 MemRCol1218 10000.000000
R11268 MemRRow1268 MemRCol1268 10000.000000
R11319 MemRRow1319 MemRCol1319 10000.000000
R11371 MemRRow1371 MemRCol1371 10000.000000
R11424 MemRRow1424 MemRCol1424 10000.000000
R11478 MemRRow1478 MemRCol1478 10000.000000
R11533 MemRRow1533 MemRCol1533 10000.000000
R11589 MemRRow1589 MemRCol1589 10000.000000
R11646 MemRRow1646 MemRCol1646 10000.000000
R137 MemRRow37 MemRCol37 10000.000000
R147 MemRRow47 MemRCol47 10000.000000
R158 MemRRow58 MemRCol58 10000.000000
R170 MemRRow70 MemRCol70 10000.000000
R183 MemRRow83 MemRCol83 10000.000000
R197 MemRRow97 MemRCol97 10000.000000
R1112 MemRRow112 MemRCol112 10000.000000
R1128 MemRRow128 MemRCol128 10000.000000
R1145 MemRRow145 MemRCol145 10000.000000
R1163 MemRRow163 MemRCol163 10000.000000
R1182 MemRRow182 MemRCol182 10000.000000
R1202 MemRRow202 MemRCol202 10000.000000
R1223 MemRRow223 MemRCol223 10000.000000
R1245 MemRRow245 MemRCol245 10000.000000
R1268 MemRRow268 MemRCol268 10000.000000
R1292 MemRRow292 MemRCol292 10000.000000
R1317 MemRRow317 MemRCol317 10000.000000
R1343 MemRRow343 MemRCol343 10000.000000
R1370 MemRRow370 MemRCol370 10000.000000
R1398 MemRRow398 MemRCol398 10000.000000
R1427 MemRRow427 MemRCol427 10000.000000
R1457 MemRRow457 MemRCol457 10000.000000
R1488 MemRRow488 MemRCol488 10000.000000
R1520 MemRRow520 MemRCol520 10000.000000
R1553 MemRRow553 MemRCol553 10000.000000
R1587 MemRRow587 MemRCol587 10000.000000
R1622 MemRRow622 MemRCol622 10000.000000
R1658 MemRRow658 MemRCol658 10000.000000
R1695 MemRRow695 MemRCol695 10000.000000
R1733 MemRRow733 MemRCol733 10000.000000
R1772 MemRRow772 MemRCol772 10000.000000
R1812 MemRRow812 MemRCol812 10000.000000
R1853 MemRRow853 MemRCol853 10000.000000
R1895 MemRRow895 MemRCol895 10000.000000
R1938 MemRRow938 MemRCol938 10000.000000
R1982 MemRRow982 MemRCol982 10000.000000
R11027 MemRRow1027 MemRCol1027 10000.000000
R11073 MemRRow1073 MemRCol1073 10000.000000
R11120 MemRRow1120 MemRCol1120 10000.000000
R11168 MemRRow1168 MemRCol1168 10000.000000
R11217 MemRRow1217 MemRCol1217 10000.000000
R11267 MemRRow1267 MemRCol1267 10000.000000
R11318 MemRRow1318 MemRCol1318 10000.000000
R11370 MemRRow1370 MemRCol1370 10000.000000
R11423 MemRRow1423 MemRCol1423 10000.000000
R11477 MemRRow1477 MemRCol1477 10000.000000
R11532 MemRRow1532 MemRCol1532 10000.000000
R11588 MemRRow1588 MemRCol1588 10000.000000
R11645 MemRRow1645 MemRCol1645 10000.000000
R11703 MemRRow1703 MemRCol1703 10000.000000
R146 MemRRow46 MemRCol46 10000.000000
R157 MemRRow57 MemRCol57 10000.000000
R169 MemRRow69 MemRCol69 10000.000000
R182 MemRRow82 MemRCol82 10000.000000
R196 MemRRow96 MemRCol96 10000.000000
R1111 MemRRow111 MemRCol111 10000.000000
R1127 MemRRow127 MemRCol127 10000.000000
R1144 MemRRow144 MemRCol144 10000.000000
R1162 MemRRow162 MemRCol162 10000.000000
R1181 MemRRow181 MemRCol181 10000.000000
R1201 MemRRow201 MemRCol201 10000.000000
R1222 MemRRow222 MemRCol222 10000.000000
R1244 MemRRow244 MemRCol244 10000.000000
R1267 MemRRow267 MemRCol267 10000.000000
R1291 MemRRow291 MemRCol291 10000.000000
R1316 MemRRow316 MemRCol316 10000.000000
R1342 MemRRow342 MemRCol342 10000.000000
R1369 MemRRow369 MemRCol369 10000.000000
R1397 MemRRow397 MemRCol397 10000.000000
R1426 MemRRow426 MemRCol426 10000.000000
R1456 MemRRow456 MemRCol456 10000.000000
R1487 MemRRow487 MemRCol487 10000.000000
R1519 MemRRow519 MemRCol519 10000.000000
R1552 MemRRow552 MemRCol552 10000.000000
R1586 MemRRow586 MemRCol586 10000.000000
R1621 MemRRow621 MemRCol621 10000.000000
R1657 MemRRow657 MemRCol657 10000.000000
R1694 MemRRow694 MemRCol694 10000.000000
R1732 MemRRow732 MemRCol732 10000.000000
R1771 MemRRow771 MemRCol771 10000.000000
R1811 MemRRow811 MemRCol811 10000.000000
R1852 MemRRow852 MemRCol852 10000.000000
R1894 MemRRow894 MemRCol894 10000.000000
R1937 MemRRow937 MemRCol937 10000.000000
R1981 MemRRow981 MemRCol981 10000.000000
R11026 MemRRow1026 MemRCol1026 10000.000000
R11072 MemRRow1072 MemRCol1072 10000.000000
R11119 MemRRow1119 MemRCol1119 10000.000000
R11167 MemRRow1167 MemRCol1167 10000.000000
R11216 MemRRow1216 MemRCol1216 10000.000000
R11266 MemRRow1266 MemRCol1266 10000.000000
R11317 MemRRow1317 MemRCol1317 10000.000000
R11369 MemRRow1369 MemRCol1369 10000.000000
R11422 MemRRow1422 MemRCol1422 10000.000000
R11476 MemRRow1476 MemRCol1476 10000.000000
R11531 MemRRow1531 MemRCol1531 10000.000000
R11587 MemRRow1587 MemRCol1587 10000.000000
R11644 MemRRow1644 MemRCol1644 10000.000000
R11702 MemRRow1702 MemRCol1702 10000.000000
R11761 MemRRow1761 MemRCol1761 10000.000000
R156 MemRRow56 MemRCol56 10000.000000
R168 MemRRow68 MemRCol68 10000.000000
R181 MemRRow81 MemRCol81 10000.000000
R195 MemRRow95 MemRCol95 10000.000000
R1110 MemRRow110 MemRCol110 10000.000000
R1126 MemRRow126 MemRCol126 10000.000000
R1143 MemRRow143 MemRCol143 10000.000000
R1161 MemRRow161 MemRCol161 10000.000000
R1180 MemRRow180 MemRCol180 10000.000000
R1200 MemRRow200 MemRCol200 10000.000000
R1221 MemRRow221 MemRCol221 10000.000000
R1243 MemRRow243 MemRCol243 10000.000000
R1266 MemRRow266 MemRCol266 10000.000000
R1290 MemRRow290 MemRCol290 10000.000000
R1315 MemRRow315 MemRCol315 10000.000000
R1341 MemRRow341 MemRCol341 10000.000000
R1368 MemRRow368 MemRCol368 10000.000000
R1396 MemRRow396 MemRCol396 10000.000000
R1425 MemRRow425 MemRCol425 10000.000000
R1455 MemRRow455 MemRCol455 10000.000000
R1486 MemRRow486 MemRCol486 10000.000000
R1518 MemRRow518 MemRCol518 10000.000000
R1551 MemRRow551 MemRCol551 10000.000000
R1585 MemRRow585 MemRCol585 10000.000000
R1620 MemRRow620 MemRCol620 10000.000000
R1656 MemRRow656 MemRCol656 10000.000000
R1693 MemRRow693 MemRCol693 10000.000000
R1731 MemRRow731 MemRCol731 10000.000000
R1770 MemRRow770 MemRCol770 10000.000000
R1810 MemRRow810 MemRCol810 10000.000000
R1851 MemRRow851 MemRCol851 10000.000000
R1893 MemRRow893 MemRCol893 10000.000000
R1936 MemRRow936 MemRCol936 10000.000000
R1980 MemRRow980 MemRCol980 10000.000000
R11025 MemRRow1025 MemRCol1025 10000.000000
R11071 MemRRow1071 MemRCol1071 10000.000000
R11118 MemRRow1118 MemRCol1118 10000.000000
R11166 MemRRow1166 MemRCol1166 10000.000000
R11215 MemRRow1215 MemRCol1215 10000.000000
R11265 MemRRow1265 MemRCol1265 10000.000000
R11316 MemRRow1316 MemRCol1316 10000.000000
R11368 MemRRow1368 MemRCol1368 10000.000000
R11421 MemRRow1421 MemRCol1421 10000.000000
R11475 MemRRow1475 MemRCol1475 10000.000000
R11530 MemRRow1530 MemRCol1530 10000.000000
R11586 MemRRow1586 MemRCol1586 10000.000000
R11643 MemRRow1643 MemRCol1643 10000.000000
R11701 MemRRow1701 MemRCol1701 10000.000000
R11760 MemRRow1760 MemRCol1760 10000.000000
R11820 MemRRow1820 MemRCol1820 10000.000000
R167 MemRRow67 MemRCol67 10000.000000
R180 MemRRow80 MemRCol80 10000.000000
R194 MemRRow94 MemRCol94 10000.000000
R1109 MemRRow109 MemRCol109 10000.000000
R1125 MemRRow125 MemRCol125 10000.000000
R1142 MemRRow142 MemRCol142 10000.000000
R1160 MemRRow160 MemRCol160 10000.000000
R1179 MemRRow179 MemRCol179 10000.000000
R1199 MemRRow199 MemRCol199 10000.000000
R1220 MemRRow220 MemRCol220 10000.000000
R1242 MemRRow242 MemRCol242 10000.000000
R1265 MemRRow265 MemRCol265 10000.000000
R1289 MemRRow289 MemRCol289 10000.000000
R1314 MemRRow314 MemRCol314 10000.000000
R1340 MemRRow340 MemRCol340 10000.000000
R1367 MemRRow367 MemRCol367 10000.000000
R1395 MemRRow395 MemRCol395 10000.000000
R1424 MemRRow424 MemRCol424 10000.000000
R1454 MemRRow454 MemRCol454 10000.000000
R1485 MemRRow485 MemRCol485 10000.000000
R1517 MemRRow517 MemRCol517 10000.000000
R1550 MemRRow550 MemRCol550 10000.000000
R1584 MemRRow584 MemRCol584 10000.000000
R1619 MemRRow619 MemRCol619 10000.000000
R1655 MemRRow655 MemRCol655 10000.000000
R1692 MemRRow692 MemRCol692 10000.000000
R1730 MemRRow730 MemRCol730 10000.000000
R1769 MemRRow769 MemRCol769 10000.000000
R1809 MemRRow809 MemRCol809 10000.000000
R1850 MemRRow850 MemRCol850 10000.000000
R1892 MemRRow892 MemRCol892 10000.000000
R1935 MemRRow935 MemRCol935 10000.000000
R1979 MemRRow979 MemRCol979 10000.000000
R11024 MemRRow1024 MemRCol1024 10000.000000
R11070 MemRRow1070 MemRCol1070 10000.000000
R11117 MemRRow1117 MemRCol1117 10000.000000
R11165 MemRRow1165 MemRCol1165 10000.000000
R11214 MemRRow1214 MemRCol1214 10000.000000
R11264 MemRRow1264 MemRCol1264 10000.000000
R11315 MemRRow1315 MemRCol1315 10000.000000
R11367 MemRRow1367 MemRCol1367 10000.000000
R11420 MemRRow1420 MemRCol1420 10000.000000
R11474 MemRRow1474 MemRCol1474 10000.000000
R11529 MemRRow1529 MemRCol1529 10000.000000
R11585 MemRRow1585 MemRCol1585 10000.000000
R11642 MemRRow1642 MemRCol1642 10000.000000
R11700 MemRRow1700 MemRCol1700 10000.000000
R11759 MemRRow1759 MemRCol1759 10000.000000
R11819 MemRRow1819 MemRCol1819 10000.000000
R11880 MemRRow1880 MemRCol1880 10000.000000
R179 MemRRow79 MemRCol79 10000.000000
R193 MemRRow93 MemRCol93 10000.000000
R1108 MemRRow108 MemRCol108 10000.000000
R1124 MemRRow124 MemRCol124 10000.000000
R1141 MemRRow141 MemRCol141 10000.000000
R1159 MemRRow159 MemRCol159 10000.000000
R1178 MemRRow178 MemRCol178 10000.000000
R1198 MemRRow198 MemRCol198 10000.000000
R1219 MemRRow219 MemRCol219 10000.000000
R1241 MemRRow241 MemRCol241 10000.000000
R1264 MemRRow264 MemRCol264 10000.000000
R1288 MemRRow288 MemRCol288 10000.000000
R1313 MemRRow313 MemRCol313 10000.000000
R1339 MemRRow339 MemRCol339 10000.000000
R1366 MemRRow366 MemRCol366 10000.000000
R1394 MemRRow394 MemRCol394 10000.000000
R1423 MemRRow423 MemRCol423 10000.000000
R1453 MemRRow453 MemRCol453 10000.000000
R1484 MemRRow484 MemRCol484 10000.000000
R1516 MemRRow516 MemRCol516 10000.000000
R1549 MemRRow549 MemRCol549 10000.000000
R1583 MemRRow583 MemRCol583 10000.000000
R1618 MemRRow618 MemRCol618 10000.000000
R1654 MemRRow654 MemRCol654 10000.000000
R1691 MemRRow691 MemRCol691 10000.000000
R1729 MemRRow729 MemRCol729 10000.000000
R1768 MemRRow768 MemRCol768 10000.000000
R1808 MemRRow808 MemRCol808 10000.000000
R1849 MemRRow849 MemRCol849 10000.000000
R1891 MemRRow891 MemRCol891 10000.000000
R1934 MemRRow934 MemRCol934 10000.000000
R1978 MemRRow978 MemRCol978 10000.000000
R11023 MemRRow1023 MemRCol1023 10000.000000
R11069 MemRRow1069 MemRCol1069 10000.000000
R11116 MemRRow1116 MemRCol1116 10000.000000
R11164 MemRRow1164 MemRCol1164 10000.000000
R11213 MemRRow1213 MemRCol1213 10000.000000
R11263 MemRRow1263 MemRCol1263 10000.000000
R11314 MemRRow1314 MemRCol1314 10000.000000
R11366 MemRRow1366 MemRCol1366 10000.000000
R11419 MemRRow1419 MemRCol1419 10000.000000
R11473 MemRRow1473 MemRCol1473 10000.000000
R11528 MemRRow1528 MemRCol1528 10000.000000
R11584 MemRRow1584 MemRCol1584 10000.000000
R11641 MemRRow1641 MemRCol1641 10000.000000
R11699 MemRRow1699 MemRCol1699 10000.000000
R11758 MemRRow1758 MemRCol1758 10000.000000
R11818 MemRRow1818 MemRCol1818 10000.000000
R11879 MemRRow1879 MemRCol1879 10000.000000
R11941 MemRRow1941 MemRCol1941 10000.000000
R192 MemRRow92 MemRCol92 10000.000000
R1107 MemRRow107 MemRCol107 10000.000000
R1123 MemRRow123 MemRCol123 10000.000000
R1140 MemRRow140 MemRCol140 10000.000000
R1158 MemRRow158 MemRCol158 10000.000000
R1177 MemRRow177 MemRCol177 10000.000000
R1197 MemRRow197 MemRCol197 10000.000000
R1218 MemRRow218 MemRCol218 10000.000000
R1240 MemRRow240 MemRCol240 10000.000000
R1263 MemRRow263 MemRCol263 10000.000000
R1287 MemRRow287 MemRCol287 10000.000000
R1312 MemRRow312 MemRCol312 10000.000000
R1338 MemRRow338 MemRCol338 10000.000000
R1365 MemRRow365 MemRCol365 10000.000000
R1393 MemRRow393 MemRCol393 10000.000000
R1422 MemRRow422 MemRCol422 10000.000000
R1452 MemRRow452 MemRCol452 10000.000000
R1483 MemRRow483 MemRCol483 10000.000000
R1515 MemRRow515 MemRCol515 10000.000000
R1548 MemRRow548 MemRCol548 10000.000000
R1582 MemRRow582 MemRCol582 10000.000000
R1617 MemRRow617 MemRCol617 10000.000000
R1653 MemRRow653 MemRCol653 10000.000000
R1690 MemRRow690 MemRCol690 10000.000000
R1728 MemRRow728 MemRCol728 10000.000000
R1767 MemRRow767 MemRCol767 10000.000000
R1807 MemRRow807 MemRCol807 10000.000000
R1848 MemRRow848 MemRCol848 10000.000000
R1890 MemRRow890 MemRCol890 10000.000000
R1933 MemRRow933 MemRCol933 10000.000000
R1977 MemRRow977 MemRCol977 10000.000000
R11022 MemRRow1022 MemRCol1022 10000.000000
R11068 MemRRow1068 MemRCol1068 10000.000000
R11115 MemRRow1115 MemRCol1115 10000.000000
R11163 MemRRow1163 MemRCol1163 10000.000000
R11212 MemRRow1212 MemRCol1212 10000.000000
R11262 MemRRow1262 MemRCol1262 10000.000000
R11313 MemRRow1313 MemRCol1313 10000.000000
R11365 MemRRow1365 MemRCol1365 10000.000000
R11418 MemRRow1418 MemRCol1418 10000.000000
R11472 MemRRow1472 MemRCol1472 10000.000000
R11527 MemRRow1527 MemRCol1527 10000.000000
R11583 MemRRow1583 MemRCol1583 10000.000000
R11640 MemRRow1640 MemRCol1640 10000.000000
R11698 MemRRow1698 MemRCol1698 10000.000000
R11757 MemRRow1757 MemRCol1757 10000.000000
R11817 MemRRow1817 MemRCol1817 10000.000000
R11878 MemRRow1878 MemRCol1878 10000.000000
R11940 MemRRow1940 MemRCol1940 10000.000000
R12003 MemRRow2003 MemRCol2003 10000.000000
R1106 MemRRow106 MemRCol106 10000.000000
R1122 MemRRow122 MemRCol122 10000.000000
R1139 MemRRow139 MemRCol139 10000.000000
R1157 MemRRow157 MemRCol157 10000.000000
R1176 MemRRow176 MemRCol176 10000.000000
R1196 MemRRow196 MemRCol196 10000.000000
R1217 MemRRow217 MemRCol217 10000.000000
R1239 MemRRow239 MemRCol239 10000.000000
R1262 MemRRow262 MemRCol262 10000.000000
R1286 MemRRow286 MemRCol286 10000.000000
R1311 MemRRow311 MemRCol311 10000.000000
R1337 MemRRow337 MemRCol337 10000.000000
R1364 MemRRow364 MemRCol364 10000.000000
R1392 MemRRow392 MemRCol392 10000.000000
R1421 MemRRow421 MemRCol421 10000.000000
R1451 MemRRow451 MemRCol451 10000.000000
R1482 MemRRow482 MemRCol482 10000.000000
R1514 MemRRow514 MemRCol514 10000.000000
R1547 MemRRow547 MemRCol547 10000.000000
R1581 MemRRow581 MemRCol581 10000.000000
R1616 MemRRow616 MemRCol616 10000.000000
R1652 MemRRow652 MemRCol652 10000.000000
R1689 MemRRow689 MemRCol689 10000.000000
R1727 MemRRow727 MemRCol727 10000.000000
R1766 MemRRow766 MemRCol766 10000.000000
R1806 MemRRow806 MemRCol806 10000.000000
R1847 MemRRow847 MemRCol847 10000.000000
R1889 MemRRow889 MemRCol889 10000.000000
R1932 MemRRow932 MemRCol932 10000.000000
R1976 MemRRow976 MemRCol976 10000.000000
R11021 MemRRow1021 MemRCol1021 10000.000000
R11067 MemRRow1067 MemRCol1067 10000.000000
R11114 MemRRow1114 MemRCol1114 10000.000000
R11162 MemRRow1162 MemRCol1162 10000.000000
R11211 MemRRow1211 MemRCol1211 10000.000000
R11261 MemRRow1261 MemRCol1261 10000.000000
R11312 MemRRow1312 MemRCol1312 10000.000000
R11364 MemRRow1364 MemRCol1364 10000.000000
R11417 MemRRow1417 MemRCol1417 10000.000000
R11471 MemRRow1471 MemRCol1471 10000.000000
R11526 MemRRow1526 MemRCol1526 10000.000000
R11582 MemRRow1582 MemRCol1582 10000.000000
R11639 MemRRow1639 MemRCol1639 10000.000000
R11697 MemRRow1697 MemRCol1697 10000.000000
R11756 MemRRow1756 MemRCol1756 10000.000000
R11816 MemRRow1816 MemRCol1816 10000.000000
R11877 MemRRow1877 MemRCol1877 10000.000000
R11939 MemRRow1939 MemRCol1939 10000.000000
R12002 MemRRow2002 MemRCol2002 10000.000000
R12066 MemRRow2066 MemRCol2066 10000.000000
R1121 MemRRow121 MemRCol121 10000.000000
R1138 MemRRow138 MemRCol138 10000.000000
R1156 MemRRow156 MemRCol156 10000.000000
R1175 MemRRow175 MemRCol175 10000.000000
R1195 MemRRow195 MemRCol195 10000.000000
R1216 MemRRow216 MemRCol216 10000.000000
R1238 MemRRow238 MemRCol238 10000.000000
R1261 MemRRow261 MemRCol261 10000.000000
R1285 MemRRow285 MemRCol285 10000.000000
R1310 MemRRow310 MemRCol310 10000.000000
R1336 MemRRow336 MemRCol336 10000.000000
R1363 MemRRow363 MemRCol363 10000.000000
R1391 MemRRow391 MemRCol391 10000.000000
R1420 MemRRow420 MemRCol420 10000.000000
R1450 MemRRow450 MemRCol450 10000.000000
R1481 MemRRow481 MemRCol481 10000.000000
R1513 MemRRow513 MemRCol513 10000.000000
R1546 MemRRow546 MemRCol546 10000.000000
R1580 MemRRow580 MemRCol580 10000.000000
R1615 MemRRow615 MemRCol615 10000.000000
R1651 MemRRow651 MemRCol651 10000.000000
R1688 MemRRow688 MemRCol688 10000.000000
R1726 MemRRow726 MemRCol726 10000.000000
R1765 MemRRow765 MemRCol765 10000.000000
R1805 MemRRow805 MemRCol805 10000.000000
R1846 MemRRow846 MemRCol846 10000.000000
R1888 MemRRow888 MemRCol888 10000.000000
R1931 MemRRow931 MemRCol931 10000.000000
R1975 MemRRow975 MemRCol975 10000.000000
R11020 MemRRow1020 MemRCol1020 10000.000000
R11066 MemRRow1066 MemRCol1066 10000.000000
R11113 MemRRow1113 MemRCol1113 10000.000000
R11161 MemRRow1161 MemRCol1161 10000.000000
R11210 MemRRow1210 MemRCol1210 10000.000000
R11260 MemRRow1260 MemRCol1260 10000.000000
R11311 MemRRow1311 MemRCol1311 10000.000000
R11363 MemRRow1363 MemRCol1363 10000.000000
R11416 MemRRow1416 MemRCol1416 10000.000000
R11470 MemRRow1470 MemRCol1470 10000.000000
R11525 MemRRow1525 MemRCol1525 10000.000000
R11581 MemRRow1581 MemRCol1581 10000.000000
R11638 MemRRow1638 MemRCol1638 10000.000000
R11696 MemRRow1696 MemRCol1696 10000.000000
R11755 MemRRow1755 MemRCol1755 10000.000000
R11815 MemRRow1815 MemRCol1815 10000.000000
R11876 MemRRow1876 MemRCol1876 10000.000000
R11938 MemRRow1938 MemRCol1938 10000.000000
R12001 MemRRow2001 MemRCol2001 10000.000000
R12065 MemRRow2065 MemRCol2065 10000.000000
R12130 MemRRow2130 MemRCol2130 10000.000000
R1137 MemRRow137 MemRCol137 10000.000000
R1155 MemRRow155 MemRCol155 10000.000000
R1174 MemRRow174 MemRCol174 10000.000000
R1194 MemRRow194 MemRCol194 10000.000000
R1215 MemRRow215 MemRCol215 10000.000000
R1237 MemRRow237 MemRCol237 10000.000000
R1260 MemRRow260 MemRCol260 10000.000000
R1284 MemRRow284 MemRCol284 10000.000000
R1309 MemRRow309 MemRCol309 10000.000000
R1335 MemRRow335 MemRCol335 10000.000000
R1362 MemRRow362 MemRCol362 10000.000000
R1390 MemRRow390 MemRCol390 10000.000000
R1419 MemRRow419 MemRCol419 10000.000000
R1449 MemRRow449 MemRCol449 10000.000000
R1480 MemRRow480 MemRCol480 10000.000000
R1512 MemRRow512 MemRCol512 10000.000000
R1545 MemRRow545 MemRCol545 10000.000000
R1579 MemRRow579 MemRCol579 10000.000000
R1614 MemRRow614 MemRCol614 10000.000000
R1650 MemRRow650 MemRCol650 10000.000000
R1687 MemRRow687 MemRCol687 10000.000000
R1725 MemRRow725 MemRCol725 10000.000000
R1764 MemRRow764 MemRCol764 10000.000000
R1804 MemRRow804 MemRCol804 10000.000000
R1845 MemRRow845 MemRCol845 10000.000000
R1887 MemRRow887 MemRCol887 10000.000000
R1930 MemRRow930 MemRCol930 10000.000000
R1974 MemRRow974 MemRCol974 10000.000000
R11019 MemRRow1019 MemRCol1019 10000.000000
R11065 MemRRow1065 MemRCol1065 10000.000000
R11112 MemRRow1112 MemRCol1112 10000.000000
R11160 MemRRow1160 MemRCol1160 10000.000000
R11209 MemRRow1209 MemRCol1209 10000.000000
R11259 MemRRow1259 MemRCol1259 10000.000000
R11310 MemRRow1310 MemRCol1310 10000.000000
R11362 MemRRow1362 MemRCol1362 10000.000000
R11415 MemRRow1415 MemRCol1415 10000.000000
R11469 MemRRow1469 MemRCol1469 10000.000000
R11524 MemRRow1524 MemRCol1524 10000.000000
R11580 MemRRow1580 MemRCol1580 10000.000000
R11637 MemRRow1637 MemRCol1637 10000.000000
R11695 MemRRow1695 MemRCol1695 10000.000000
R11754 MemRRow1754 MemRCol1754 10000.000000
R11814 MemRRow1814 MemRCol1814 10000.000000
R11875 MemRRow1875 MemRCol1875 10000.000000
R11937 MemRRow1937 MemRCol1937 10000.000000
R12000 MemRRow2000 MemRCol2000 10000.000000
R12064 MemRRow2064 MemRCol2064 10000.000000
R12129 MemRRow2129 MemRCol2129 10000.000000
R12195 MemRRow2195 MemRCol2195 10000.000000
R1154 MemRRow154 MemRCol154 10000.000000
R1173 MemRRow173 MemRCol173 10000.000000
R1193 MemRRow193 MemRCol193 10000.000000
R1214 MemRRow214 MemRCol214 10000.000000
R1236 MemRRow236 MemRCol236 10000.000000
R1259 MemRRow259 MemRCol259 10000.000000
R1283 MemRRow283 MemRCol283 10000.000000
R1308 MemRRow308 MemRCol308 10000.000000
R1334 MemRRow334 MemRCol334 10000.000000
R1361 MemRRow361 MemRCol361 10000.000000
R1389 MemRRow389 MemRCol389 10000.000000
R1418 MemRRow418 MemRCol418 10000.000000
R1448 MemRRow448 MemRCol448 10000.000000
R1479 MemRRow479 MemRCol479 10000.000000
R1511 MemRRow511 MemRCol511 10000.000000
R1544 MemRRow544 MemRCol544 10000.000000
R1578 MemRRow578 MemRCol578 10000.000000
R1613 MemRRow613 MemRCol613 10000.000000
R1649 MemRRow649 MemRCol649 10000.000000
R1686 MemRRow686 MemRCol686 10000.000000
R1724 MemRRow724 MemRCol724 10000.000000
R1763 MemRRow763 MemRCol763 10000.000000
R1803 MemRRow803 MemRCol803 10000.000000
R1844 MemRRow844 MemRCol844 10000.000000
R1886 MemRRow886 MemRCol886 10000.000000
R1929 MemRRow929 MemRCol929 10000.000000
R1973 MemRRow973 MemRCol973 10000.000000
R11018 MemRRow1018 MemRCol1018 10000.000000
R11064 MemRRow1064 MemRCol1064 10000.000000
R11111 MemRRow1111 MemRCol1111 10000.000000
R11159 MemRRow1159 MemRCol1159 10000.000000
R11208 MemRRow1208 MemRCol1208 10000.000000
R11258 MemRRow1258 MemRCol1258 10000.000000
R11309 MemRRow1309 MemRCol1309 10000.000000
R11361 MemRRow1361 MemRCol1361 10000.000000
R11414 MemRRow1414 MemRCol1414 10000.000000
R11468 MemRRow1468 MemRCol1468 10000.000000
R11523 MemRRow1523 MemRCol1523 10000.000000
R11579 MemRRow1579 MemRCol1579 10000.000000
R11636 MemRRow1636 MemRCol1636 10000.000000
R11694 MemRRow1694 MemRCol1694 10000.000000
R11753 MemRRow1753 MemRCol1753 10000.000000
R11813 MemRRow1813 MemRCol1813 10000.000000
R11874 MemRRow1874 MemRCol1874 10000.000000
R11936 MemRRow1936 MemRCol1936 10000.000000
R11999 MemRRow1999 MemRCol1999 10000.000000
R12063 MemRRow2063 MemRCol2063 10000.000000
R12128 MemRRow2128 MemRCol2128 10000.000000
R12194 MemRRow2194 MemRCol2194 10000.000000
R12261 MemRRow2261 MemRCol2261 10000.000000
R1172 MemRRow172 MemRCol172 10000.000000
R1192 MemRRow192 MemRCol192 10000.000000
R1213 MemRRow213 MemRCol213 10000.000000
R1235 MemRRow235 MemRCol235 10000.000000
R1258 MemRRow258 MemRCol258 10000.000000
R1282 MemRRow282 MemRCol282 10000.000000
R1307 MemRRow307 MemRCol307 10000.000000
R1333 MemRRow333 MemRCol333 10000.000000
R1360 MemRRow360 MemRCol360 10000.000000
R1388 MemRRow388 MemRCol388 10000.000000
R1417 MemRRow417 MemRCol417 10000.000000
R1447 MemRRow447 MemRCol447 10000.000000
R1478 MemRRow478 MemRCol478 10000.000000
R1510 MemRRow510 MemRCol510 10000.000000
R1543 MemRRow543 MemRCol543 10000.000000
R1577 MemRRow577 MemRCol577 10000.000000
R1612 MemRRow612 MemRCol612 10000.000000
R1648 MemRRow648 MemRCol648 10000.000000
R1685 MemRRow685 MemRCol685 10000.000000
R1723 MemRRow723 MemRCol723 10000.000000
R1762 MemRRow762 MemRCol762 10000.000000
R1802 MemRRow802 MemRCol802 10000.000000
R1843 MemRRow843 MemRCol843 10000.000000
R1885 MemRRow885 MemRCol885 10000.000000
R1928 MemRRow928 MemRCol928 10000.000000
R1972 MemRRow972 MemRCol972 10000.000000
R11017 MemRRow1017 MemRCol1017 10000.000000
R11063 MemRRow1063 MemRCol1063 10000.000000
R11110 MemRRow1110 MemRCol1110 10000.000000
R11158 MemRRow1158 MemRCol1158 10000.000000
R11207 MemRRow1207 MemRCol1207 10000.000000
R11257 MemRRow1257 MemRCol1257 10000.000000
R11308 MemRRow1308 MemRCol1308 10000.000000
R11360 MemRRow1360 MemRCol1360 10000.000000
R11413 MemRRow1413 MemRCol1413 10000.000000
R11467 MemRRow1467 MemRCol1467 10000.000000
R11522 MemRRow1522 MemRCol1522 10000.000000
R11578 MemRRow1578 MemRCol1578 10000.000000
R11635 MemRRow1635 MemRCol1635 10000.000000
R11693 MemRRow1693 MemRCol1693 10000.000000
R11752 MemRRow1752 MemRCol1752 10000.000000
R11812 MemRRow1812 MemRCol1812 10000.000000
R11873 MemRRow1873 MemRCol1873 10000.000000
R11935 MemRRow1935 MemRCol1935 10000.000000
R11998 MemRRow1998 MemRCol1998 10000.000000
R12062 MemRRow2062 MemRCol2062 10000.000000
R12127 MemRRow2127 MemRCol2127 10000.000000
R12193 MemRRow2193 MemRCol2193 10000.000000
R12260 MemRRow2260 MemRCol2260 10000.000000
R12328 MemRRow2328 MemRCol2328 10000.000000
R1191 MemRRow191 MemRCol191 10000.000000
R1212 MemRRow212 MemRCol212 10000.000000
R1234 MemRRow234 MemRCol234 10000.000000
R1257 MemRRow257 MemRCol257 10000.000000
R1281 MemRRow281 MemRCol281 10000.000000
R1306 MemRRow306 MemRCol306 10000.000000
R1332 MemRRow332 MemRCol332 10000.000000
R1359 MemRRow359 MemRCol359 10000.000000
R1387 MemRRow387 MemRCol387 10000.000000
R1416 MemRRow416 MemRCol416 10000.000000
R1446 MemRRow446 MemRCol446 10000.000000
R1477 MemRRow477 MemRCol477 10000.000000
R1509 MemRRow509 MemRCol509 10000.000000
R1542 MemRRow542 MemRCol542 10000.000000
R1576 MemRRow576 MemRCol576 10000.000000
R1611 MemRRow611 MemRCol611 10000.000000
R1647 MemRRow647 MemRCol647 10000.000000
R1684 MemRRow684 MemRCol684 10000.000000
R1722 MemRRow722 MemRCol722 10000.000000
R1761 MemRRow761 MemRCol761 10000.000000
R1801 MemRRow801 MemRCol801 10000.000000
R1842 MemRRow842 MemRCol842 10000.000000
R1884 MemRRow884 MemRCol884 10000.000000
R1927 MemRRow927 MemRCol927 10000.000000
R1971 MemRRow971 MemRCol971 10000.000000
R11016 MemRRow1016 MemRCol1016 10000.000000
R11062 MemRRow1062 MemRCol1062 10000.000000
R11109 MemRRow1109 MemRCol1109 10000.000000
R11157 MemRRow1157 MemRCol1157 10000.000000
R11206 MemRRow1206 MemRCol1206 10000.000000
R11256 MemRRow1256 MemRCol1256 10000.000000
R11307 MemRRow1307 MemRCol1307 10000.000000
R11359 MemRRow1359 MemRCol1359 10000.000000
R11412 MemRRow1412 MemRCol1412 10000.000000
R11466 MemRRow1466 MemRCol1466 10000.000000
R11521 MemRRow1521 MemRCol1521 10000.000000
R11577 MemRRow1577 MemRCol1577 10000.000000
R11634 MemRRow1634 MemRCol1634 10000.000000
R11692 MemRRow1692 MemRCol1692 10000.000000
R11751 MemRRow1751 MemRCol1751 10000.000000
R11811 MemRRow1811 MemRCol1811 10000.000000
R11872 MemRRow1872 MemRCol1872 10000.000000
R11934 MemRRow1934 MemRCol1934 10000.000000
R11997 MemRRow1997 MemRCol1997 10000.000000
R12061 MemRRow2061 MemRCol2061 10000.000000
R12126 MemRRow2126 MemRCol2126 10000.000000
R12192 MemRRow2192 MemRCol2192 10000.000000
R12259 MemRRow2259 MemRCol2259 10000.000000
R12327 MemRRow2327 MemRCol2327 10000.000000
R12396 MemRRow2396 MemRCol2396 10000.000000
R1211 MemRRow211 MemRCol211 10000.000000
R1233 MemRRow233 MemRCol233 10000.000000
R1256 MemRRow256 MemRCol256 10000.000000
R1280 MemRRow280 MemRCol280 10000.000000
R1305 MemRRow305 MemRCol305 10000.000000
R1331 MemRRow331 MemRCol331 10000.000000
R1358 MemRRow358 MemRCol358 10000.000000
R1386 MemRRow386 MemRCol386 10000.000000
R1415 MemRRow415 MemRCol415 10000.000000
R1445 MemRRow445 MemRCol445 10000.000000
R1476 MemRRow476 MemRCol476 10000.000000
R1508 MemRRow508 MemRCol508 10000.000000
R1541 MemRRow541 MemRCol541 10000.000000
R1575 MemRRow575 MemRCol575 10000.000000
R1610 MemRRow610 MemRCol610 10000.000000
R1646 MemRRow646 MemRCol646 10000.000000
R1683 MemRRow683 MemRCol683 10000.000000
R1721 MemRRow721 MemRCol721 10000.000000
R1760 MemRRow760 MemRCol760 10000.000000
R1800 MemRRow800 MemRCol800 10000.000000
R1841 MemRRow841 MemRCol841 10000.000000
R1883 MemRRow883 MemRCol883 10000.000000
R1926 MemRRow926 MemRCol926 10000.000000
R1970 MemRRow970 MemRCol970 10000.000000
R11015 MemRRow1015 MemRCol1015 10000.000000
R11061 MemRRow1061 MemRCol1061 10000.000000
R11108 MemRRow1108 MemRCol1108 10000.000000
R11156 MemRRow1156 MemRCol1156 10000.000000
R11205 MemRRow1205 MemRCol1205 10000.000000
R11255 MemRRow1255 MemRCol1255 10000.000000
R11306 MemRRow1306 MemRCol1306 10000.000000
R11358 MemRRow1358 MemRCol1358 10000.000000
R11411 MemRRow1411 MemRCol1411 10000.000000
R11465 MemRRow1465 MemRCol1465 10000.000000
R11520 MemRRow1520 MemRCol1520 10000.000000
R11576 MemRRow1576 MemRCol1576 10000.000000
R11633 MemRRow1633 MemRCol1633 10000.000000
R11691 MemRRow1691 MemRCol1691 10000.000000
R11750 MemRRow1750 MemRCol1750 10000.000000
R11810 MemRRow1810 MemRCol1810 10000.000000
R11871 MemRRow1871 MemRCol1871 10000.000000
R11933 MemRRow1933 MemRCol1933 10000.000000
R11996 MemRRow1996 MemRCol1996 10000.000000
R12060 MemRRow2060 MemRCol2060 10000.000000
R12125 MemRRow2125 MemRCol2125 10000.000000
R12191 MemRRow2191 MemRCol2191 10000.000000
R12258 MemRRow2258 MemRCol2258 10000.000000
R12326 MemRRow2326 MemRCol2326 10000.000000
R12395 MemRRow2395 MemRCol2395 10000.000000
R12465 MemRRow2465 MemRCol2465 10000.000000
R1232 MemRRow232 MemRCol232 10000.000000
R1255 MemRRow255 MemRCol255 10000.000000
R1279 MemRRow279 MemRCol279 10000.000000
R1304 MemRRow304 MemRCol304 10000.000000
R1330 MemRRow330 MemRCol330 10000.000000
R1357 MemRRow357 MemRCol357 10000.000000
R1385 MemRRow385 MemRCol385 10000.000000
R1414 MemRRow414 MemRCol414 10000.000000
R1444 MemRRow444 MemRCol444 10000.000000
R1475 MemRRow475 MemRCol475 10000.000000
R1507 MemRRow507 MemRCol507 10000.000000
R1540 MemRRow540 MemRCol540 10000.000000
R1574 MemRRow574 MemRCol574 10000.000000
R1609 MemRRow609 MemRCol609 10000.000000
R1645 MemRRow645 MemRCol645 10000.000000
R1682 MemRRow682 MemRCol682 10000.000000
R1720 MemRRow720 MemRCol720 10000.000000
R1759 MemRRow759 MemRCol759 10000.000000
R1799 MemRRow799 MemRCol799 10000.000000
R1840 MemRRow840 MemRCol840 10000.000000
R1882 MemRRow882 MemRCol882 10000.000000
R1925 MemRRow925 MemRCol925 10000.000000
R1969 MemRRow969 MemRCol969 10000.000000
R11014 MemRRow1014 MemRCol1014 10000.000000
R11060 MemRRow1060 MemRCol1060 10000.000000
R11107 MemRRow1107 MemRCol1107 10000.000000
R11155 MemRRow1155 MemRCol1155 10000.000000
R11204 MemRRow1204 MemRCol1204 10000.000000
R11254 MemRRow1254 MemRCol1254 10000.000000
R11305 MemRRow1305 MemRCol1305 10000.000000
R11357 MemRRow1357 MemRCol1357 10000.000000
R11410 MemRRow1410 MemRCol1410 10000.000000
R11464 MemRRow1464 MemRCol1464 10000.000000
R11519 MemRRow1519 MemRCol1519 10000.000000
R11575 MemRRow1575 MemRCol1575 10000.000000
R11632 MemRRow1632 MemRCol1632 10000.000000
R11690 MemRRow1690 MemRCol1690 10000.000000
R11749 MemRRow1749 MemRCol1749 10000.000000
R11809 MemRRow1809 MemRCol1809 10000.000000
R11870 MemRRow1870 MemRCol1870 10000.000000
R11932 MemRRow1932 MemRCol1932 10000.000000
R11995 MemRRow1995 MemRCol1995 10000.000000
R12059 MemRRow2059 MemRCol2059 10000.000000
R12124 MemRRow2124 MemRCol2124 10000.000000
R12190 MemRRow2190 MemRCol2190 10000.000000
R12257 MemRRow2257 MemRCol2257 10000.000000
R12325 MemRRow2325 MemRCol2325 10000.000000
R12394 MemRRow2394 MemRCol2394 10000.000000
R12464 MemRRow2464 MemRCol2464 10000.000000
R12535 MemRRow2535 MemRCol2535 10000.000000
R1254 MemRRow254 MemRCol254 10000.000000
R1278 MemRRow278 MemRCol278 10000.000000
R1303 MemRRow303 MemRCol303 10000.000000
R1329 MemRRow329 MemRCol329 10000.000000
R1356 MemRRow356 MemRCol356 10000.000000
R1384 MemRRow384 MemRCol384 10000.000000
R1413 MemRRow413 MemRCol413 10000.000000
R1443 MemRRow443 MemRCol443 10000.000000
R1474 MemRRow474 MemRCol474 10000.000000
R1506 MemRRow506 MemRCol506 10000.000000
R1539 MemRRow539 MemRCol539 10000.000000
R1573 MemRRow573 MemRCol573 10000.000000
R1608 MemRRow608 MemRCol608 10000.000000
R1644 MemRRow644 MemRCol644 10000.000000
R1681 MemRRow681 MemRCol681 10000.000000
R1719 MemRRow719 MemRCol719 10000.000000
R1758 MemRRow758 MemRCol758 10000.000000
R1798 MemRRow798 MemRCol798 10000.000000
R1839 MemRRow839 MemRCol839 10000.000000
R1881 MemRRow881 MemRCol881 10000.000000
R1924 MemRRow924 MemRCol924 10000.000000
R1968 MemRRow968 MemRCol968 10000.000000
R11013 MemRRow1013 MemRCol1013 10000.000000
R11059 MemRRow1059 MemRCol1059 10000.000000
R11106 MemRRow1106 MemRCol1106 10000.000000
R11154 MemRRow1154 MemRCol1154 10000.000000
R11203 MemRRow1203 MemRCol1203 10000.000000
R11253 MemRRow1253 MemRCol1253 10000.000000
R11304 MemRRow1304 MemRCol1304 10000.000000
R11356 MemRRow1356 MemRCol1356 10000.000000
R11409 MemRRow1409 MemRCol1409 10000.000000
R11463 MemRRow1463 MemRCol1463 10000.000000
R11518 MemRRow1518 MemRCol1518 10000.000000
R11574 MemRRow1574 MemRCol1574 10000.000000
R11631 MemRRow1631 MemRCol1631 10000.000000
R11689 MemRRow1689 MemRCol1689 10000.000000
R11748 MemRRow1748 MemRCol1748 10000.000000
R11808 MemRRow1808 MemRCol1808 10000.000000
R11869 MemRRow1869 MemRCol1869 10000.000000
R11931 MemRRow1931 MemRCol1931 10000.000000
R11994 MemRRow1994 MemRCol1994 10000.000000
R12058 MemRRow2058 MemRCol2058 10000.000000
R12123 MemRRow2123 MemRCol2123 10000.000000
R12189 MemRRow2189 MemRCol2189 10000.000000
R12256 MemRRow2256 MemRCol2256 10000.000000
R12324 MemRRow2324 MemRCol2324 10000.000000
R12393 MemRRow2393 MemRCol2393 10000.000000
R12463 MemRRow2463 MemRCol2463 10000.000000
R12534 MemRRow2534 MemRCol2534 10000.000000
R12606 MemRRow2606 MemRCol2606 10000.000000
R1277 MemRRow277 MemRCol277 10000.000000
R1302 MemRRow302 MemRCol302 10000.000000
R1328 MemRRow328 MemRCol328 10000.000000
R1355 MemRRow355 MemRCol355 10000.000000
R1383 MemRRow383 MemRCol383 10000.000000
R1412 MemRRow412 MemRCol412 10000.000000
R1442 MemRRow442 MemRCol442 10000.000000
R1473 MemRRow473 MemRCol473 10000.000000
R1505 MemRRow505 MemRCol505 10000.000000
R1538 MemRRow538 MemRCol538 10000.000000
R1572 MemRRow572 MemRCol572 10000.000000
R1607 MemRRow607 MemRCol607 10000.000000
R1643 MemRRow643 MemRCol643 10000.000000
R1680 MemRRow680 MemRCol680 10000.000000
R1718 MemRRow718 MemRCol718 10000.000000
R1757 MemRRow757 MemRCol757 10000.000000
R1797 MemRRow797 MemRCol797 10000.000000
R1838 MemRRow838 MemRCol838 10000.000000
R1880 MemRRow880 MemRCol880 10000.000000
R1923 MemRRow923 MemRCol923 10000.000000
R1967 MemRRow967 MemRCol967 10000.000000
R11012 MemRRow1012 MemRCol1012 10000.000000
R11058 MemRRow1058 MemRCol1058 10000.000000
R11105 MemRRow1105 MemRCol1105 10000.000000
R11153 MemRRow1153 MemRCol1153 10000.000000
R11202 MemRRow1202 MemRCol1202 10000.000000
R11252 MemRRow1252 MemRCol1252 10000.000000
R11303 MemRRow1303 MemRCol1303 10000.000000
R11355 MemRRow1355 MemRCol1355 10000.000000
R11408 MemRRow1408 MemRCol1408 10000.000000
R11462 MemRRow1462 MemRCol1462 10000.000000
R11517 MemRRow1517 MemRCol1517 10000.000000
R11573 MemRRow1573 MemRCol1573 10000.000000
R11630 MemRRow1630 MemRCol1630 10000.000000
R11688 MemRRow1688 MemRCol1688 10000.000000
R11747 MemRRow1747 MemRCol1747 10000.000000
R11807 MemRRow1807 MemRCol1807 10000.000000
R11868 MemRRow1868 MemRCol1868 10000.000000
R11930 MemRRow1930 MemRCol1930 10000.000000
R11993 MemRRow1993 MemRCol1993 10000.000000
R12057 MemRRow2057 MemRCol2057 10000.000000
R12122 MemRRow2122 MemRCol2122 10000.000000
R12188 MemRRow2188 MemRCol2188 10000.000000
R12255 MemRRow2255 MemRCol2255 10000.000000
R12323 MemRRow2323 MemRCol2323 10000.000000
R12392 MemRRow2392 MemRCol2392 10000.000000
R12462 MemRRow2462 MemRCol2462 10000.000000
R12533 MemRRow2533 MemRCol2533 10000.000000
R12605 MemRRow2605 MemRCol2605 10000.000000
R12678 MemRRow2678 MemRCol2678 10000.000000
R1301 MemRRow301 MemRCol301 10000.000000
R1327 MemRRow327 MemRCol327 10000.000000
R1354 MemRRow354 MemRCol354 10000.000000
R1382 MemRRow382 MemRCol382 10000.000000
R1411 MemRRow411 MemRCol411 10000.000000
R1441 MemRRow441 MemRCol441 10000.000000
R1472 MemRRow472 MemRCol472 10000.000000
R1504 MemRRow504 MemRCol504 10000.000000
R1537 MemRRow537 MemRCol537 10000.000000
R1571 MemRRow571 MemRCol571 10000.000000
R1606 MemRRow606 MemRCol606 10000.000000
R1642 MemRRow642 MemRCol642 10000.000000
R1679 MemRRow679 MemRCol679 10000.000000
R1717 MemRRow717 MemRCol717 10000.000000
R1756 MemRRow756 MemRCol756 10000.000000
R1796 MemRRow796 MemRCol796 10000.000000
R1837 MemRRow837 MemRCol837 10000.000000
R1879 MemRRow879 MemRCol879 10000.000000
R1922 MemRRow922 MemRCol922 10000.000000
R1966 MemRRow966 MemRCol966 10000.000000
R11011 MemRRow1011 MemRCol1011 10000.000000
R11057 MemRRow1057 MemRCol1057 10000.000000
R11104 MemRRow1104 MemRCol1104 10000.000000
R11152 MemRRow1152 MemRCol1152 10000.000000
R11201 MemRRow1201 MemRCol1201 10000.000000
R11251 MemRRow1251 MemRCol1251 10000.000000
R11302 MemRRow1302 MemRCol1302 10000.000000
R11354 MemRRow1354 MemRCol1354 10000.000000
R11407 MemRRow1407 MemRCol1407 10000.000000
R11461 MemRRow1461 MemRCol1461 10000.000000
R11516 MemRRow1516 MemRCol1516 10000.000000
R11572 MemRRow1572 MemRCol1572 10000.000000
R11629 MemRRow1629 MemRCol1629 10000.000000
R11687 MemRRow1687 MemRCol1687 10000.000000
R11746 MemRRow1746 MemRCol1746 10000.000000
R11806 MemRRow1806 MemRCol1806 10000.000000
R11867 MemRRow1867 MemRCol1867 10000.000000
R11929 MemRRow1929 MemRCol1929 10000.000000
R11992 MemRRow1992 MemRCol1992 10000.000000
R12056 MemRRow2056 MemRCol2056 10000.000000
R12121 MemRRow2121 MemRCol2121 10000.000000
R12187 MemRRow2187 MemRCol2187 10000.000000
R12254 MemRRow2254 MemRCol2254 10000.000000
R12322 MemRRow2322 MemRCol2322 10000.000000
R12391 MemRRow2391 MemRCol2391 10000.000000
R12461 MemRRow2461 MemRCol2461 10000.000000
R12532 MemRRow2532 MemRCol2532 10000.000000
R12604 MemRRow2604 MemRCol2604 10000.000000
R12677 MemRRow2677 MemRCol2677 10000.000000
R12751 MemRRow2751 MemRCol2751 10000.000000
R1326 MemRRow326 MemRCol326 10000.000000
R1353 MemRRow353 MemRCol353 10000.000000
R1381 MemRRow381 MemRCol381 10000.000000
R1410 MemRRow410 MemRCol410 10000.000000
R1440 MemRRow440 MemRCol440 10000.000000
R1471 MemRRow471 MemRCol471 10000.000000
R1503 MemRRow503 MemRCol503 10000.000000
R1536 MemRRow536 MemRCol536 10000.000000
R1570 MemRRow570 MemRCol570 10000.000000
R1605 MemRRow605 MemRCol605 10000.000000
R1641 MemRRow641 MemRCol641 10000.000000
R1678 MemRRow678 MemRCol678 10000.000000
R1716 MemRRow716 MemRCol716 10000.000000
R1755 MemRRow755 MemRCol755 10000.000000
R1795 MemRRow795 MemRCol795 10000.000000
R1836 MemRRow836 MemRCol836 10000.000000
R1878 MemRRow878 MemRCol878 10000.000000
R1921 MemRRow921 MemRCol921 10000.000000
R1965 MemRRow965 MemRCol965 10000.000000
R11010 MemRRow1010 MemRCol1010 10000.000000
R11056 MemRRow1056 MemRCol1056 10000.000000
R11103 MemRRow1103 MemRCol1103 10000.000000
R11151 MemRRow1151 MemRCol1151 10000.000000
R11200 MemRRow1200 MemRCol1200 10000.000000
R11250 MemRRow1250 MemRCol1250 10000.000000
R11301 MemRRow1301 MemRCol1301 10000.000000
R11353 MemRRow1353 MemRCol1353 10000.000000
R11406 MemRRow1406 MemRCol1406 10000.000000
R11460 MemRRow1460 MemRCol1460 10000.000000
R11515 MemRRow1515 MemRCol1515 10000.000000
R11571 MemRRow1571 MemRCol1571 10000.000000
R11628 MemRRow1628 MemRCol1628 10000.000000
R11686 MemRRow1686 MemRCol1686 10000.000000
R11745 MemRRow1745 MemRCol1745 10000.000000
R11805 MemRRow1805 MemRCol1805 10000.000000
R11866 MemRRow1866 MemRCol1866 10000.000000
R11928 MemRRow1928 MemRCol1928 10000.000000
R11991 MemRRow1991 MemRCol1991 10000.000000
R12055 MemRRow2055 MemRCol2055 10000.000000
R12120 MemRRow2120 MemRCol2120 10000.000000
R12186 MemRRow2186 MemRCol2186 10000.000000
R12253 MemRRow2253 MemRCol2253 10000.000000
R12321 MemRRow2321 MemRCol2321 10000.000000
R12390 MemRRow2390 MemRCol2390 10000.000000
R12460 MemRRow2460 MemRCol2460 10000.000000
R12531 MemRRow2531 MemRCol2531 10000.000000
R12603 MemRRow2603 MemRCol2603 10000.000000
R12676 MemRRow2676 MemRCol2676 10000.000000
R12750 MemRRow2750 MemRCol2750 10000.000000
R12825 MemRRow2825 MemRCol2825 10000.000000
R1352 MemRRow352 MemRCol352 10000.000000
R1380 MemRRow380 MemRCol380 10000.000000
R1409 MemRRow409 MemRCol409 10000.000000
R1439 MemRRow439 MemRCol439 10000.000000
R1470 MemRRow470 MemRCol470 10000.000000
R1502 MemRRow502 MemRCol502 10000.000000
R1535 MemRRow535 MemRCol535 10000.000000
R1569 MemRRow569 MemRCol569 10000.000000
R1604 MemRRow604 MemRCol604 10000.000000
R1640 MemRRow640 MemRCol640 10000.000000
R1677 MemRRow677 MemRCol677 10000.000000
R1715 MemRRow715 MemRCol715 10000.000000
R1754 MemRRow754 MemRCol754 10000.000000
R1794 MemRRow794 MemRCol794 10000.000000
R1835 MemRRow835 MemRCol835 10000.000000
R1877 MemRRow877 MemRCol877 10000.000000
R1920 MemRRow920 MemRCol920 10000.000000
R1964 MemRRow964 MemRCol964 10000.000000
R11009 MemRRow1009 MemRCol1009 10000.000000
R11055 MemRRow1055 MemRCol1055 10000.000000
R11102 MemRRow1102 MemRCol1102 10000.000000
R11150 MemRRow1150 MemRCol1150 10000.000000
R11199 MemRRow1199 MemRCol1199 10000.000000
R11249 MemRRow1249 MemRCol1249 10000.000000
R11300 MemRRow1300 MemRCol1300 10000.000000
R11352 MemRRow1352 MemRCol1352 10000.000000
R11405 MemRRow1405 MemRCol1405 10000.000000
R11459 MemRRow1459 MemRCol1459 10000.000000
R11514 MemRRow1514 MemRCol1514 10000.000000
R11570 MemRRow1570 MemRCol1570 10000.000000
R11627 MemRRow1627 MemRCol1627 10000.000000
R11685 MemRRow1685 MemRCol1685 10000.000000
R11744 MemRRow1744 MemRCol1744 10000.000000
R11804 MemRRow1804 MemRCol1804 10000.000000
R11865 MemRRow1865 MemRCol1865 10000.000000
R11927 MemRRow1927 MemRCol1927 10000.000000
R11990 MemRRow1990 MemRCol1990 10000.000000
R12054 MemRRow2054 MemRCol2054 10000.000000
R12119 MemRRow2119 MemRCol2119 10000.000000
R12185 MemRRow2185 MemRCol2185 10000.000000
R12252 MemRRow2252 MemRCol2252 10000.000000
R12320 MemRRow2320 MemRCol2320 10000.000000
R12389 MemRRow2389 MemRCol2389 10000.000000
R12459 MemRRow2459 MemRCol2459 10000.000000
R12530 MemRRow2530 MemRCol2530 10000.000000
R12602 MemRRow2602 MemRCol2602 10000.000000
R12675 MemRRow2675 MemRCol2675 10000.000000
R12749 MemRRow2749 MemRCol2749 10000.000000
R12824 MemRRow2824 MemRCol2824 10000.000000
R12900 MemRRow2900 MemRCol2900 10000.000000
R1379 MemRRow379 MemRCol379 10000.000000
R1408 MemRRow408 MemRCol408 10000.000000
R1438 MemRRow438 MemRCol438 10000.000000
R1469 MemRRow469 MemRCol469 10000.000000
R1501 MemRRow501 MemRCol501 10000.000000
R1534 MemRRow534 MemRCol534 10000.000000
R1568 MemRRow568 MemRCol568 10000.000000
R1603 MemRRow603 MemRCol603 10000.000000
R1639 MemRRow639 MemRCol639 10000.000000
R1676 MemRRow676 MemRCol676 10000.000000
R1714 MemRRow714 MemRCol714 10000.000000
R1753 MemRRow753 MemRCol753 10000.000000
R1793 MemRRow793 MemRCol793 10000.000000
R1834 MemRRow834 MemRCol834 10000.000000
R1876 MemRRow876 MemRCol876 10000.000000
R1919 MemRRow919 MemRCol919 10000.000000
R1963 MemRRow963 MemRCol963 10000.000000
R11008 MemRRow1008 MemRCol1008 10000.000000
R11054 MemRRow1054 MemRCol1054 10000.000000
R11101 MemRRow1101 MemRCol1101 10000.000000
R11149 MemRRow1149 MemRCol1149 10000.000000
R11198 MemRRow1198 MemRCol1198 10000.000000
R11248 MemRRow1248 MemRCol1248 10000.000000
R11299 MemRRow1299 MemRCol1299 10000.000000
R11351 MemRRow1351 MemRCol1351 10000.000000
R11404 MemRRow1404 MemRCol1404 10000.000000
R11458 MemRRow1458 MemRCol1458 10000.000000
R11513 MemRRow1513 MemRCol1513 10000.000000
R11569 MemRRow1569 MemRCol1569 10000.000000
R11626 MemRRow1626 MemRCol1626 10000.000000
R11684 MemRRow1684 MemRCol1684 10000.000000
R11743 MemRRow1743 MemRCol1743 10000.000000
R11803 MemRRow1803 MemRCol1803 10000.000000
R11864 MemRRow1864 MemRCol1864 10000.000000
R11926 MemRRow1926 MemRCol1926 10000.000000
R11989 MemRRow1989 MemRCol1989 10000.000000
R12053 MemRRow2053 MemRCol2053 10000.000000
R12118 MemRRow2118 MemRCol2118 10000.000000
R12184 MemRRow2184 MemRCol2184 10000.000000
R12251 MemRRow2251 MemRCol2251 10000.000000
R12319 MemRRow2319 MemRCol2319 10000.000000
R12388 MemRRow2388 MemRCol2388 10000.000000
R12458 MemRRow2458 MemRCol2458 10000.000000
R12529 MemRRow2529 MemRCol2529 10000.000000
R12601 MemRRow2601 MemRCol2601 10000.000000
R12674 MemRRow2674 MemRCol2674 10000.000000
R12748 MemRRow2748 MemRCol2748 10000.000000
R12823 MemRRow2823 MemRCol2823 10000.000000
R12899 MemRRow2899 MemRCol2899 10000.000000
R12976 MemRRow2976 MemRCol2976 10000.000000
R1407 MemRRow407 MemRCol407 10000.000000
R1437 MemRRow437 MemRCol437 10000.000000
R1468 MemRRow468 MemRCol468 10000.000000
R1500 MemRRow500 MemRCol500 10000.000000
R1533 MemRRow533 MemRCol533 10000.000000
R1567 MemRRow567 MemRCol567 10000.000000
R1602 MemRRow602 MemRCol602 10000.000000
R1638 MemRRow638 MemRCol638 10000.000000
R1675 MemRRow675 MemRCol675 10000.000000
R1713 MemRRow713 MemRCol713 10000.000000
R1752 MemRRow752 MemRCol752 10000.000000
R1792 MemRRow792 MemRCol792 10000.000000
R1833 MemRRow833 MemRCol833 10000.000000
R1875 MemRRow875 MemRCol875 10000.000000
R1918 MemRRow918 MemRCol918 10000.000000
R1962 MemRRow962 MemRCol962 10000.000000
R11007 MemRRow1007 MemRCol1007 10000.000000
R11053 MemRRow1053 MemRCol1053 10000.000000
R11100 MemRRow1100 MemRCol1100 10000.000000
R11148 MemRRow1148 MemRCol1148 10000.000000
R11197 MemRRow1197 MemRCol1197 10000.000000
R11247 MemRRow1247 MemRCol1247 10000.000000
R11298 MemRRow1298 MemRCol1298 10000.000000
R11350 MemRRow1350 MemRCol1350 10000.000000
R11403 MemRRow1403 MemRCol1403 10000.000000
R11457 MemRRow1457 MemRCol1457 10000.000000
R11512 MemRRow1512 MemRCol1512 10000.000000
R11568 MemRRow1568 MemRCol1568 10000.000000
R11625 MemRRow1625 MemRCol1625 10000.000000
R11683 MemRRow1683 MemRCol1683 10000.000000
R11742 MemRRow1742 MemRCol1742 10000.000000
R11802 MemRRow1802 MemRCol1802 10000.000000
R11863 MemRRow1863 MemRCol1863 10000.000000
R11925 MemRRow1925 MemRCol1925 10000.000000
R11988 MemRRow1988 MemRCol1988 10000.000000
R12052 MemRRow2052 MemRCol2052 10000.000000
R12117 MemRRow2117 MemRCol2117 10000.000000
R12183 MemRRow2183 MemRCol2183 10000.000000
R12250 MemRRow2250 MemRCol2250 10000.000000
R12318 MemRRow2318 MemRCol2318 10000.000000
R12387 MemRRow2387 MemRCol2387 10000.000000
R12457 MemRRow2457 MemRCol2457 10000.000000
R12528 MemRRow2528 MemRCol2528 10000.000000
R12600 MemRRow2600 MemRCol2600 10000.000000
R12673 MemRRow2673 MemRCol2673 10000.000000
R12747 MemRRow2747 MemRCol2747 10000.000000
R12822 MemRRow2822 MemRCol2822 10000.000000
R12898 MemRRow2898 MemRCol2898 10000.000000
R12975 MemRRow2975 MemRCol2975 10000.000000
R13053 MemRRow3053 MemRCol3053 10000.000000
R1436 MemRRow436 MemRCol436 10000.000000
R1467 MemRRow467 MemRCol467 10000.000000
R1499 MemRRow499 MemRCol499 10000.000000
R1532 MemRRow532 MemRCol532 10000.000000
R1566 MemRRow566 MemRCol566 10000.000000
R1601 MemRRow601 MemRCol601 10000.000000
R1637 MemRRow637 MemRCol637 10000.000000
R1674 MemRRow674 MemRCol674 10000.000000
R1712 MemRRow712 MemRCol712 10000.000000
R1751 MemRRow751 MemRCol751 10000.000000
R1791 MemRRow791 MemRCol791 10000.000000
R1832 MemRRow832 MemRCol832 10000.000000
R1874 MemRRow874 MemRCol874 10000.000000
R1917 MemRRow917 MemRCol917 10000.000000
R1961 MemRRow961 MemRCol961 10000.000000
R11006 MemRRow1006 MemRCol1006 10000.000000
R11052 MemRRow1052 MemRCol1052 10000.000000
R11099 MemRRow1099 MemRCol1099 10000.000000
R11147 MemRRow1147 MemRCol1147 10000.000000
R11196 MemRRow1196 MemRCol1196 10000.000000
R11246 MemRRow1246 MemRCol1246 10000.000000
R11297 MemRRow1297 MemRCol1297 10000.000000
R11349 MemRRow1349 MemRCol1349 10000.000000
R11402 MemRRow1402 MemRCol1402 10000.000000
R11456 MemRRow1456 MemRCol1456 10000.000000
R11511 MemRRow1511 MemRCol1511 10000.000000
R11567 MemRRow1567 MemRCol1567 10000.000000
R11624 MemRRow1624 MemRCol1624 10000.000000
R11682 MemRRow1682 MemRCol1682 10000.000000
R11741 MemRRow1741 MemRCol1741 10000.000000
R11801 MemRRow1801 MemRCol1801 10000.000000
R11862 MemRRow1862 MemRCol1862 10000.000000
R11924 MemRRow1924 MemRCol1924 10000.000000
R11987 MemRRow1987 MemRCol1987 10000.000000
R12051 MemRRow2051 MemRCol2051 10000.000000
R12116 MemRRow2116 MemRCol2116 10000.000000
R12182 MemRRow2182 MemRCol2182 10000.000000
R12249 MemRRow2249 MemRCol2249 10000.000000
R12317 MemRRow2317 MemRCol2317 10000.000000
R12386 MemRRow2386 MemRCol2386 10000.000000
R12456 MemRRow2456 MemRCol2456 10000.000000
R12527 MemRRow2527 MemRCol2527 10000.000000
R12599 MemRRow2599 MemRCol2599 10000.000000
R12672 MemRRow2672 MemRCol2672 10000.000000
R12746 MemRRow2746 MemRCol2746 10000.000000
R12821 MemRRow2821 MemRCol2821 10000.000000
R12897 MemRRow2897 MemRCol2897 10000.000000
R12974 MemRRow2974 MemRCol2974 10000.000000
R13052 MemRRow3052 MemRCol3052 10000.000000
R13131 MemRRow3131 MemRCol3131 10000.000000
R1466 MemRRow466 MemRCol466 10000.000000
R1498 MemRRow498 MemRCol498 10000.000000
R1531 MemRRow531 MemRCol531 10000.000000
R1565 MemRRow565 MemRCol565 10000.000000
R1600 MemRRow600 MemRCol600 10000.000000
R1636 MemRRow636 MemRCol636 10000.000000
R1673 MemRRow673 MemRCol673 10000.000000
R1711 MemRRow711 MemRCol711 10000.000000
R1750 MemRRow750 MemRCol750 10000.000000
R1790 MemRRow790 MemRCol790 10000.000000
R1831 MemRRow831 MemRCol831 10000.000000
R1873 MemRRow873 MemRCol873 10000.000000
R1916 MemRRow916 MemRCol916 10000.000000
R1960 MemRRow960 MemRCol960 10000.000000
R11005 MemRRow1005 MemRCol1005 10000.000000
R11051 MemRRow1051 MemRCol1051 10000.000000
R11098 MemRRow1098 MemRCol1098 10000.000000
R11146 MemRRow1146 MemRCol1146 10000.000000
R11195 MemRRow1195 MemRCol1195 10000.000000
R11245 MemRRow1245 MemRCol1245 10000.000000
R11296 MemRRow1296 MemRCol1296 10000.000000
R11348 MemRRow1348 MemRCol1348 10000.000000
R11401 MemRRow1401 MemRCol1401 10000.000000
R11455 MemRRow1455 MemRCol1455 10000.000000
R11510 MemRRow1510 MemRCol1510 10000.000000
R11566 MemRRow1566 MemRCol1566 10000.000000
R11623 MemRRow1623 MemRCol1623 10000.000000
R11681 MemRRow1681 MemRCol1681 10000.000000
R11740 MemRRow1740 MemRCol1740 10000.000000
R11800 MemRRow1800 MemRCol1800 10000.000000
R11861 MemRRow1861 MemRCol1861 10000.000000
R11923 MemRRow1923 MemRCol1923 10000.000000
R11986 MemRRow1986 MemRCol1986 10000.000000
R12050 MemRRow2050 MemRCol2050 10000.000000
R12115 MemRRow2115 MemRCol2115 10000.000000
R12181 MemRRow2181 MemRCol2181 10000.000000
R12248 MemRRow2248 MemRCol2248 10000.000000
R12316 MemRRow2316 MemRCol2316 10000.000000
R12385 MemRRow2385 MemRCol2385 10000.000000
R12455 MemRRow2455 MemRCol2455 10000.000000
R12526 MemRRow2526 MemRCol2526 10000.000000
R12598 MemRRow2598 MemRCol2598 10000.000000
R12671 MemRRow2671 MemRCol2671 10000.000000
R12745 MemRRow2745 MemRCol2745 10000.000000
R12820 MemRRow2820 MemRCol2820 10000.000000
R12896 MemRRow2896 MemRCol2896 10000.000000
R12973 MemRRow2973 MemRCol2973 10000.000000
R13051 MemRRow3051 MemRCol3051 10000.000000
R13130 MemRRow3130 MemRCol3130 10000.000000
R13210 MemRRow3210 MemRCol3210 10000.000000
R1497 MemRRow497 MemRCol497 10000.000000
R1530 MemRRow530 MemRCol530 10000.000000
R1564 MemRRow564 MemRCol564 10000.000000
R1599 MemRRow599 MemRCol599 10000.000000
R1635 MemRRow635 MemRCol635 10000.000000
R1672 MemRRow672 MemRCol672 10000.000000
R1710 MemRRow710 MemRCol710 10000.000000
R1749 MemRRow749 MemRCol749 10000.000000
R1789 MemRRow789 MemRCol789 10000.000000
R1830 MemRRow830 MemRCol830 10000.000000
R1872 MemRRow872 MemRCol872 10000.000000
R1915 MemRRow915 MemRCol915 10000.000000
R1959 MemRRow959 MemRCol959 10000.000000
R11004 MemRRow1004 MemRCol1004 10000.000000
R11050 MemRRow1050 MemRCol1050 10000.000000
R11097 MemRRow1097 MemRCol1097 10000.000000
R11145 MemRRow1145 MemRCol1145 10000.000000
R11194 MemRRow1194 MemRCol1194 10000.000000
R11244 MemRRow1244 MemRCol1244 10000.000000
R11295 MemRRow1295 MemRCol1295 10000.000000
R11347 MemRRow1347 MemRCol1347 10000.000000
R11400 MemRRow1400 MemRCol1400 10000.000000
R11454 MemRRow1454 MemRCol1454 10000.000000
R11509 MemRRow1509 MemRCol1509 10000.000000
R11565 MemRRow1565 MemRCol1565 10000.000000
R11622 MemRRow1622 MemRCol1622 10000.000000
R11680 MemRRow1680 MemRCol1680 10000.000000
R11739 MemRRow1739 MemRCol1739 10000.000000
R11799 MemRRow1799 MemRCol1799 10000.000000
R11860 MemRRow1860 MemRCol1860 10000.000000
R11922 MemRRow1922 MemRCol1922 10000.000000
R11985 MemRRow1985 MemRCol1985 10000.000000
R12049 MemRRow2049 MemRCol2049 10000.000000
R12114 MemRRow2114 MemRCol2114 10000.000000
R12180 MemRRow2180 MemRCol2180 10000.000000
R12247 MemRRow2247 MemRCol2247 10000.000000
R12315 MemRRow2315 MemRCol2315 10000.000000
R12384 MemRRow2384 MemRCol2384 10000.000000
R12454 MemRRow2454 MemRCol2454 10000.000000
R12525 MemRRow2525 MemRCol2525 10000.000000
R12597 MemRRow2597 MemRCol2597 10000.000000
R12670 MemRRow2670 MemRCol2670 10000.000000
R12744 MemRRow2744 MemRCol2744 10000.000000
R12819 MemRRow2819 MemRCol2819 10000.000000
R12895 MemRRow2895 MemRCol2895 10000.000000
R12972 MemRRow2972 MemRCol2972 10000.000000
R13050 MemRRow3050 MemRCol3050 10000.000000
R13129 MemRRow3129 MemRCol3129 10000.000000
R13209 MemRRow3209 MemRCol3209 10000.000000
R13290 MemRRow3290 MemRCol3290 10000.000000
R1529 MemRRow529 MemRCol529 10000.000000
R1563 MemRRow563 MemRCol563 10000.000000
R1598 MemRRow598 MemRCol598 10000.000000
R1634 MemRRow634 MemRCol634 10000.000000
R1671 MemRRow671 MemRCol671 10000.000000
R1709 MemRRow709 MemRCol709 10000.000000
R1748 MemRRow748 MemRCol748 10000.000000
R1788 MemRRow788 MemRCol788 10000.000000
R1829 MemRRow829 MemRCol829 10000.000000
R1871 MemRRow871 MemRCol871 10000.000000
R1914 MemRRow914 MemRCol914 10000.000000
R1958 MemRRow958 MemRCol958 10000.000000
R11003 MemRRow1003 MemRCol1003 10000.000000
R11049 MemRRow1049 MemRCol1049 10000.000000
R11096 MemRRow1096 MemRCol1096 10000.000000
R11144 MemRRow1144 MemRCol1144 10000.000000
R11193 MemRRow1193 MemRCol1193 10000.000000
R11243 MemRRow1243 MemRCol1243 10000.000000
R11294 MemRRow1294 MemRCol1294 10000.000000
R11346 MemRRow1346 MemRCol1346 10000.000000
R11399 MemRRow1399 MemRCol1399 10000.000000
R11453 MemRRow1453 MemRCol1453 10000.000000
R11508 MemRRow1508 MemRCol1508 10000.000000
R11564 MemRRow1564 MemRCol1564 10000.000000
R11621 MemRRow1621 MemRCol1621 10000.000000
R11679 MemRRow1679 MemRCol1679 10000.000000
R11738 MemRRow1738 MemRCol1738 10000.000000
R11798 MemRRow1798 MemRCol1798 10000.000000
R11859 MemRRow1859 MemRCol1859 10000.000000
R11921 MemRRow1921 MemRCol1921 10000.000000
R11984 MemRRow1984 MemRCol1984 10000.000000
R12048 MemRRow2048 MemRCol2048 10000.000000
R12113 MemRRow2113 MemRCol2113 10000.000000
R12179 MemRRow2179 MemRCol2179 10000.000000
R12246 MemRRow2246 MemRCol2246 10000.000000
R12314 MemRRow2314 MemRCol2314 10000.000000
R12383 MemRRow2383 MemRCol2383 10000.000000
R12453 MemRRow2453 MemRCol2453 10000.000000
R12524 MemRRow2524 MemRCol2524 10000.000000
R12596 MemRRow2596 MemRCol2596 10000.000000
R12669 MemRRow2669 MemRCol2669 10000.000000
R12743 MemRRow2743 MemRCol2743 10000.000000
R12818 MemRRow2818 MemRCol2818 10000.000000
R12894 MemRRow2894 MemRCol2894 10000.000000
R12971 MemRRow2971 MemRCol2971 10000.000000
R13049 MemRRow3049 MemRCol3049 10000.000000
R13128 MemRRow3128 MemRCol3128 10000.000000
R13208 MemRRow3208 MemRCol3208 10000.000000
R13289 MemRRow3289 MemRCol3289 10000.000000
R13371 MemRRow3371 MemRCol3371 10000.000000
R1562 MemRRow562 MemRCol562 10000.000000
R1597 MemRRow597 MemRCol597 10000.000000
R1633 MemRRow633 MemRCol633 10000.000000
R1670 MemRRow670 MemRCol670 10000.000000
R1708 MemRRow708 MemRCol708 10000.000000
R1747 MemRRow747 MemRCol747 10000.000000
R1787 MemRRow787 MemRCol787 10000.000000
R1828 MemRRow828 MemRCol828 10000.000000
R1870 MemRRow870 MemRCol870 10000.000000
R1913 MemRRow913 MemRCol913 10000.000000
R1957 MemRRow957 MemRCol957 10000.000000
R11002 MemRRow1002 MemRCol1002 10000.000000
R11048 MemRRow1048 MemRCol1048 10000.000000
R11095 MemRRow1095 MemRCol1095 10000.000000
R11143 MemRRow1143 MemRCol1143 10000.000000
R11192 MemRRow1192 MemRCol1192 10000.000000
R11242 MemRRow1242 MemRCol1242 10000.000000
R11293 MemRRow1293 MemRCol1293 10000.000000
R11345 MemRRow1345 MemRCol1345 10000.000000
R11398 MemRRow1398 MemRCol1398 10000.000000
R11452 MemRRow1452 MemRCol1452 10000.000000
R11507 MemRRow1507 MemRCol1507 10000.000000
R11563 MemRRow1563 MemRCol1563 10000.000000
R11620 MemRRow1620 MemRCol1620 10000.000000
R11678 MemRRow1678 MemRCol1678 10000.000000
R11737 MemRRow1737 MemRCol1737 10000.000000
R11797 MemRRow1797 MemRCol1797 10000.000000
R11858 MemRRow1858 MemRCol1858 10000.000000
R11920 MemRRow1920 MemRCol1920 10000.000000
R11983 MemRRow1983 MemRCol1983 10000.000000
R12047 MemRRow2047 MemRCol2047 10000.000000
R12112 MemRRow2112 MemRCol2112 10000.000000
R12178 MemRRow2178 MemRCol2178 10000.000000
R12245 MemRRow2245 MemRCol2245 10000.000000
R12313 MemRRow2313 MemRCol2313 10000.000000
R12382 MemRRow2382 MemRCol2382 10000.000000
R12452 MemRRow2452 MemRCol2452 10000.000000
R12523 MemRRow2523 MemRCol2523 10000.000000
R12595 MemRRow2595 MemRCol2595 10000.000000
R12668 MemRRow2668 MemRCol2668 10000.000000
R12742 MemRRow2742 MemRCol2742 10000.000000
R12817 MemRRow2817 MemRCol2817 10000.000000
R12893 MemRRow2893 MemRCol2893 10000.000000
R12970 MemRRow2970 MemRCol2970 10000.000000
R13048 MemRRow3048 MemRCol3048 10000.000000
R13127 MemRRow3127 MemRCol3127 10000.000000
R13207 MemRRow3207 MemRCol3207 10000.000000
R13288 MemRRow3288 MemRCol3288 10000.000000
R13370 MemRRow3370 MemRCol3370 10000.000000
R13453 MemRRow3453 MemRCol3453 10000.000000
R1596 MemRRow596 MemRCol596 10000.000000
R1632 MemRRow632 MemRCol632 10000.000000
R1669 MemRRow669 MemRCol669 10000.000000
R1707 MemRRow707 MemRCol707 10000.000000
R1746 MemRRow746 MemRCol746 10000.000000
R1786 MemRRow786 MemRCol786 10000.000000
R1827 MemRRow827 MemRCol827 10000.000000
R1869 MemRRow869 MemRCol869 10000.000000
R1912 MemRRow912 MemRCol912 10000.000000
R1956 MemRRow956 MemRCol956 10000.000000
R11001 MemRRow1001 MemRCol1001 10000.000000
R11047 MemRRow1047 MemRCol1047 10000.000000
R11094 MemRRow1094 MemRCol1094 10000.000000
R11142 MemRRow1142 MemRCol1142 10000.000000
R11191 MemRRow1191 MemRCol1191 10000.000000
R11241 MemRRow1241 MemRCol1241 10000.000000
R11292 MemRRow1292 MemRCol1292 10000.000000
R11344 MemRRow1344 MemRCol1344 10000.000000
R11397 MemRRow1397 MemRCol1397 10000.000000
R11451 MemRRow1451 MemRCol1451 10000.000000
R11506 MemRRow1506 MemRCol1506 10000.000000
R11562 MemRRow1562 MemRCol1562 10000.000000
R11619 MemRRow1619 MemRCol1619 10000.000000
R11677 MemRRow1677 MemRCol1677 10000.000000
R11736 MemRRow1736 MemRCol1736 10000.000000
R11796 MemRRow1796 MemRCol1796 10000.000000
R11857 MemRRow1857 MemRCol1857 10000.000000
R11919 MemRRow1919 MemRCol1919 10000.000000
R11982 MemRRow1982 MemRCol1982 10000.000000
R12046 MemRRow2046 MemRCol2046 10000.000000
R12111 MemRRow2111 MemRCol2111 10000.000000
R12177 MemRRow2177 MemRCol2177 10000.000000
R12244 MemRRow2244 MemRCol2244 10000.000000
R12312 MemRRow2312 MemRCol2312 10000.000000
R12381 MemRRow2381 MemRCol2381 10000.000000
R12451 MemRRow2451 MemRCol2451 10000.000000
R12522 MemRRow2522 MemRCol2522 10000.000000
R12594 MemRRow2594 MemRCol2594 10000.000000
R12667 MemRRow2667 MemRCol2667 10000.000000
R12741 MemRRow2741 MemRCol2741 10000.000000
R12816 MemRRow2816 MemRCol2816 10000.000000
R12892 MemRRow2892 MemRCol2892 10000.000000
R12969 MemRRow2969 MemRCol2969 10000.000000
R13047 MemRRow3047 MemRCol3047 10000.000000
R13126 MemRRow3126 MemRCol3126 10000.000000
R13206 MemRRow3206 MemRCol3206 10000.000000
R13287 MemRRow3287 MemRCol3287 10000.000000
R13369 MemRRow3369 MemRCol3369 10000.000000
R13452 MemRRow3452 MemRCol3452 10000.000000
R13536 MemRRow3536 MemRCol3536 10000.000000
R1631 MemRRow631 MemRCol631 10000.000000
R1668 MemRRow668 MemRCol668 10000.000000
R1706 MemRRow706 MemRCol706 10000.000000
R1745 MemRRow745 MemRCol745 10000.000000
R1785 MemRRow785 MemRCol785 10000.000000
R1826 MemRRow826 MemRCol826 10000.000000
R1868 MemRRow868 MemRCol868 10000.000000
R1911 MemRRow911 MemRCol911 10000.000000
R1955 MemRRow955 MemRCol955 10000.000000
R11000 MemRRow1000 MemRCol1000 10000.000000
R11046 MemRRow1046 MemRCol1046 10000.000000
R11093 MemRRow1093 MemRCol1093 10000.000000
R11141 MemRRow1141 MemRCol1141 10000.000000
R11190 MemRRow1190 MemRCol1190 10000.000000
R11240 MemRRow1240 MemRCol1240 10000.000000
R11291 MemRRow1291 MemRCol1291 10000.000000
R11343 MemRRow1343 MemRCol1343 10000.000000
R11396 MemRRow1396 MemRCol1396 10000.000000
R11450 MemRRow1450 MemRCol1450 10000.000000
R11505 MemRRow1505 MemRCol1505 10000.000000
R11561 MemRRow1561 MemRCol1561 10000.000000
R11618 MemRRow1618 MemRCol1618 10000.000000
R11676 MemRRow1676 MemRCol1676 10000.000000
R11735 MemRRow1735 MemRCol1735 10000.000000
R11795 MemRRow1795 MemRCol1795 10000.000000
R11856 MemRRow1856 MemRCol1856 10000.000000
R11918 MemRRow1918 MemRCol1918 10000.000000
R11981 MemRRow1981 MemRCol1981 10000.000000
R12045 MemRRow2045 MemRCol2045 10000.000000
R12110 MemRRow2110 MemRCol2110 10000.000000
R12176 MemRRow2176 MemRCol2176 10000.000000
R12243 MemRRow2243 MemRCol2243 10000.000000
R12311 MemRRow2311 MemRCol2311 10000.000000
R12380 MemRRow2380 MemRCol2380 10000.000000
R12450 MemRRow2450 MemRCol2450 10000.000000
R12521 MemRRow2521 MemRCol2521 10000.000000
R12593 MemRRow2593 MemRCol2593 10000.000000
R12666 MemRRow2666 MemRCol2666 10000.000000
R12740 MemRRow2740 MemRCol2740 10000.000000
R12815 MemRRow2815 MemRCol2815 10000.000000
R12891 MemRRow2891 MemRCol2891 10000.000000
R12968 MemRRow2968 MemRCol2968 10000.000000
R13046 MemRRow3046 MemRCol3046 10000.000000
R13125 MemRRow3125 MemRCol3125 10000.000000
R13205 MemRRow3205 MemRCol3205 10000.000000
R13286 MemRRow3286 MemRCol3286 10000.000000
R13368 MemRRow3368 MemRCol3368 10000.000000
R13451 MemRRow3451 MemRCol3451 10000.000000
R13535 MemRRow3535 MemRCol3535 10000.000000
R13620 MemRRow3620 MemRCol3620 10000.000000
R1667 MemRRow667 MemRCol667 10000.000000
R1705 MemRRow705 MemRCol705 10000.000000
R1744 MemRRow744 MemRCol744 10000.000000
R1784 MemRRow784 MemRCol784 10000.000000
R1825 MemRRow825 MemRCol825 10000.000000
R1867 MemRRow867 MemRCol867 10000.000000
R1910 MemRRow910 MemRCol910 10000.000000
R1954 MemRRow954 MemRCol954 10000.000000
R1999 MemRRow999 MemRCol999 10000.000000
R11045 MemRRow1045 MemRCol1045 10000.000000
R11092 MemRRow1092 MemRCol1092 10000.000000
R11140 MemRRow1140 MemRCol1140 10000.000000
R11189 MemRRow1189 MemRCol1189 10000.000000
R11239 MemRRow1239 MemRCol1239 10000.000000
R11290 MemRRow1290 MemRCol1290 10000.000000
R11342 MemRRow1342 MemRCol1342 10000.000000
R11395 MemRRow1395 MemRCol1395 10000.000000
R11449 MemRRow1449 MemRCol1449 10000.000000
R11504 MemRRow1504 MemRCol1504 10000.000000
R11560 MemRRow1560 MemRCol1560 10000.000000
R11617 MemRRow1617 MemRCol1617 10000.000000
R11675 MemRRow1675 MemRCol1675 10000.000000
R11734 MemRRow1734 MemRCol1734 10000.000000
R11794 MemRRow1794 MemRCol1794 10000.000000
R11855 MemRRow1855 MemRCol1855 10000.000000
R11917 MemRRow1917 MemRCol1917 10000.000000
R11980 MemRRow1980 MemRCol1980 10000.000000
R12044 MemRRow2044 MemRCol2044 10000.000000
R12109 MemRRow2109 MemRCol2109 10000.000000
R12175 MemRRow2175 MemRCol2175 10000.000000
R12242 MemRRow2242 MemRCol2242 10000.000000
R12310 MemRRow2310 MemRCol2310 10000.000000
R12379 MemRRow2379 MemRCol2379 10000.000000
R12449 MemRRow2449 MemRCol2449 10000.000000
R12520 MemRRow2520 MemRCol2520 10000.000000
R12592 MemRRow2592 MemRCol2592 10000.000000
R12665 MemRRow2665 MemRCol2665 10000.000000
R12739 MemRRow2739 MemRCol2739 10000.000000
R12814 MemRRow2814 MemRCol2814 10000.000000
R12890 MemRRow2890 MemRCol2890 10000.000000
R12967 MemRRow2967 MemRCol2967 10000.000000
R13045 MemRRow3045 MemRCol3045 10000.000000
R13124 MemRRow3124 MemRCol3124 10000.000000
R13204 MemRRow3204 MemRCol3204 10000.000000
R13285 MemRRow3285 MemRCol3285 10000.000000
R13367 MemRRow3367 MemRCol3367 10000.000000
R13450 MemRRow3450 MemRCol3450 10000.000000
R13534 MemRRow3534 MemRCol3534 10000.000000
R13619 MemRRow3619 MemRCol3619 10000.000000
R13705 MemRRow3705 MemRCol3705 10000.000000
R1704 MemRRow704 MemRCol704 10000.000000
R1743 MemRRow743 MemRCol743 10000.000000
R1783 MemRRow783 MemRCol783 10000.000000
R1824 MemRRow824 MemRCol824 10000.000000
R1866 MemRRow866 MemRCol866 10000.000000
R1909 MemRRow909 MemRCol909 10000.000000
R1953 MemRRow953 MemRCol953 10000.000000
R1998 MemRRow998 MemRCol998 10000.000000
R11044 MemRRow1044 MemRCol1044 10000.000000
R11091 MemRRow1091 MemRCol1091 10000.000000
R11139 MemRRow1139 MemRCol1139 10000.000000
R11188 MemRRow1188 MemRCol1188 10000.000000
R11238 MemRRow1238 MemRCol1238 10000.000000
R11289 MemRRow1289 MemRCol1289 10000.000000
R11341 MemRRow1341 MemRCol1341 10000.000000
R11394 MemRRow1394 MemRCol1394 10000.000000
R11448 MemRRow1448 MemRCol1448 10000.000000
R11503 MemRRow1503 MemRCol1503 10000.000000
R11559 MemRRow1559 MemRCol1559 10000.000000
R11616 MemRRow1616 MemRCol1616 10000.000000
R11674 MemRRow1674 MemRCol1674 10000.000000
R11733 MemRRow1733 MemRCol1733 10000.000000
R11793 MemRRow1793 MemRCol1793 10000.000000
R11854 MemRRow1854 MemRCol1854 10000.000000
R11916 MemRRow1916 MemRCol1916 10000.000000
R11979 MemRRow1979 MemRCol1979 10000.000000
R12043 MemRRow2043 MemRCol2043 10000.000000
R12108 MemRRow2108 MemRCol2108 10000.000000
R12174 MemRRow2174 MemRCol2174 10000.000000
R12241 MemRRow2241 MemRCol2241 10000.000000
R12309 MemRRow2309 MemRCol2309 10000.000000
R12378 MemRRow2378 MemRCol2378 10000.000000
R12448 MemRRow2448 MemRCol2448 10000.000000
R12519 MemRRow2519 MemRCol2519 10000.000000
R12591 MemRRow2591 MemRCol2591 10000.000000
R12664 MemRRow2664 MemRCol2664 10000.000000
R12738 MemRRow2738 MemRCol2738 10000.000000
R12813 MemRRow2813 MemRCol2813 10000.000000
R12889 MemRRow2889 MemRCol2889 10000.000000
R12966 MemRRow2966 MemRCol2966 10000.000000
R13044 MemRRow3044 MemRCol3044 10000.000000
R13123 MemRRow3123 MemRCol3123 10000.000000
R13203 MemRRow3203 MemRCol3203 10000.000000
R13284 MemRRow3284 MemRCol3284 10000.000000
R13366 MemRRow3366 MemRCol3366 10000.000000
R13449 MemRRow3449 MemRCol3449 10000.000000
R13533 MemRRow3533 MemRCol3533 10000.000000
R13618 MemRRow3618 MemRCol3618 10000.000000
R13704 MemRRow3704 MemRCol3704 10000.000000
R13791 MemRRow3791 MemRCol3791 10000.000000
R1742 MemRRow742 MemRCol742 10000.000000
R1782 MemRRow782 MemRCol782 10000.000000
R1823 MemRRow823 MemRCol823 10000.000000
R1865 MemRRow865 MemRCol865 10000.000000
R1908 MemRRow908 MemRCol908 10000.000000
R1952 MemRRow952 MemRCol952 10000.000000
R1997 MemRRow997 MemRCol997 10000.000000
R11043 MemRRow1043 MemRCol1043 10000.000000
R11090 MemRRow1090 MemRCol1090 10000.000000
R11138 MemRRow1138 MemRCol1138 10000.000000
R11187 MemRRow1187 MemRCol1187 10000.000000
R11237 MemRRow1237 MemRCol1237 10000.000000
R11288 MemRRow1288 MemRCol1288 10000.000000
R11340 MemRRow1340 MemRCol1340 10000.000000
R11393 MemRRow1393 MemRCol1393 10000.000000
R11447 MemRRow1447 MemRCol1447 10000.000000
R11502 MemRRow1502 MemRCol1502 10000.000000
R11558 MemRRow1558 MemRCol1558 10000.000000
R11615 MemRRow1615 MemRCol1615 10000.000000
R11673 MemRRow1673 MemRCol1673 10000.000000
R11732 MemRRow1732 MemRCol1732 10000.000000
R11792 MemRRow1792 MemRCol1792 10000.000000
R11853 MemRRow1853 MemRCol1853 10000.000000
R11915 MemRRow1915 MemRCol1915 10000.000000
R11978 MemRRow1978 MemRCol1978 10000.000000
R12042 MemRRow2042 MemRCol2042 10000.000000
R12107 MemRRow2107 MemRCol2107 10000.000000
R12173 MemRRow2173 MemRCol2173 10000.000000
R12240 MemRRow2240 MemRCol2240 10000.000000
R12308 MemRRow2308 MemRCol2308 10000.000000
R12377 MemRRow2377 MemRCol2377 10000.000000
R12447 MemRRow2447 MemRCol2447 10000.000000
R12518 MemRRow2518 MemRCol2518 10000.000000
R12590 MemRRow2590 MemRCol2590 10000.000000
R12663 MemRRow2663 MemRCol2663 10000.000000
R12737 MemRRow2737 MemRCol2737 10000.000000
R12812 MemRRow2812 MemRCol2812 10000.000000
R12888 MemRRow2888 MemRCol2888 10000.000000
R12965 MemRRow2965 MemRCol2965 10000.000000
R13043 MemRRow3043 MemRCol3043 10000.000000
R13122 MemRRow3122 MemRCol3122 10000.000000
R13202 MemRRow3202 MemRCol3202 10000.000000
R13283 MemRRow3283 MemRCol3283 10000.000000
R13365 MemRRow3365 MemRCol3365 10000.000000
R13448 MemRRow3448 MemRCol3448 10000.000000
R13532 MemRRow3532 MemRCol3532 10000.000000
R13617 MemRRow3617 MemRCol3617 10000.000000
R13703 MemRRow3703 MemRCol3703 10000.000000
R13790 MemRRow3790 MemRCol3790 10000.000000
R13878 MemRRow3878 MemRCol3878 10000.000000
R1781 MemRRow781 MemRCol781 10000.000000
R1822 MemRRow822 MemRCol822 10000.000000
R1864 MemRRow864 MemRCol864 10000.000000
R1907 MemRRow907 MemRCol907 10000.000000
R1951 MemRRow951 MemRCol951 10000.000000
R1996 MemRRow996 MemRCol996 10000.000000
R11042 MemRRow1042 MemRCol1042 10000.000000
R11089 MemRRow1089 MemRCol1089 10000.000000
R11137 MemRRow1137 MemRCol1137 10000.000000
R11186 MemRRow1186 MemRCol1186 10000.000000
R11236 MemRRow1236 MemRCol1236 10000.000000
R11287 MemRRow1287 MemRCol1287 10000.000000
R11339 MemRRow1339 MemRCol1339 10000.000000
R11392 MemRRow1392 MemRCol1392 10000.000000
R11446 MemRRow1446 MemRCol1446 10000.000000
R11501 MemRRow1501 MemRCol1501 10000.000000
R11557 MemRRow1557 MemRCol1557 10000.000000
R11614 MemRRow1614 MemRCol1614 10000.000000
R11672 MemRRow1672 MemRCol1672 10000.000000
R11731 MemRRow1731 MemRCol1731 10000.000000
R11791 MemRRow1791 MemRCol1791 10000.000000
R11852 MemRRow1852 MemRCol1852 10000.000000
R11914 MemRRow1914 MemRCol1914 10000.000000
R11977 MemRRow1977 MemRCol1977 10000.000000
R12041 MemRRow2041 MemRCol2041 10000.000000
R12106 MemRRow2106 MemRCol2106 10000.000000
R12172 MemRRow2172 MemRCol2172 10000.000000
R12239 MemRRow2239 MemRCol2239 10000.000000
R12307 MemRRow2307 MemRCol2307 10000.000000
R12376 MemRRow2376 MemRCol2376 10000.000000
R12446 MemRRow2446 MemRCol2446 10000.000000
R12517 MemRRow2517 MemRCol2517 10000.000000
R12589 MemRRow2589 MemRCol2589 10000.000000
R12662 MemRRow2662 MemRCol2662 10000.000000
R12736 MemRRow2736 MemRCol2736 10000.000000
R12811 MemRRow2811 MemRCol2811 10000.000000
R12887 MemRRow2887 MemRCol2887 10000.000000
R12964 MemRRow2964 MemRCol2964 10000.000000
R13042 MemRRow3042 MemRCol3042 10000.000000
R13121 MemRRow3121 MemRCol3121 10000.000000
R13201 MemRRow3201 MemRCol3201 10000.000000
R13282 MemRRow3282 MemRCol3282 10000.000000
R13364 MemRRow3364 MemRCol3364 10000.000000
R13447 MemRRow3447 MemRCol3447 10000.000000
R13531 MemRRow3531 MemRCol3531 10000.000000
R13616 MemRRow3616 MemRCol3616 10000.000000
R13702 MemRRow3702 MemRCol3702 10000.000000
R13789 MemRRow3789 MemRCol3789 10000.000000
R13877 MemRRow3877 MemRCol3877 10000.000000
R13966 MemRRow3966 MemRCol3966 10000.000000
R1821 MemRRow821 MemRCol821 10000.000000
R1863 MemRRow863 MemRCol863 10000.000000
R1906 MemRRow906 MemRCol906 10000.000000
R1950 MemRRow950 MemRCol950 10000.000000
R1995 MemRRow995 MemRCol995 10000.000000
R11041 MemRRow1041 MemRCol1041 10000.000000
R11088 MemRRow1088 MemRCol1088 10000.000000
R11136 MemRRow1136 MemRCol1136 10000.000000
R11185 MemRRow1185 MemRCol1185 10000.000000
R11235 MemRRow1235 MemRCol1235 10000.000000
R11286 MemRRow1286 MemRCol1286 10000.000000
R11338 MemRRow1338 MemRCol1338 10000.000000
R11391 MemRRow1391 MemRCol1391 10000.000000
R11445 MemRRow1445 MemRCol1445 10000.000000
R11500 MemRRow1500 MemRCol1500 10000.000000
R11556 MemRRow1556 MemRCol1556 10000.000000
R11613 MemRRow1613 MemRCol1613 10000.000000
R11671 MemRRow1671 MemRCol1671 10000.000000
R11730 MemRRow1730 MemRCol1730 10000.000000
R11790 MemRRow1790 MemRCol1790 10000.000000
R11851 MemRRow1851 MemRCol1851 10000.000000
R11913 MemRRow1913 MemRCol1913 10000.000000
R11976 MemRRow1976 MemRCol1976 10000.000000
R12040 MemRRow2040 MemRCol2040 10000.000000
R12105 MemRRow2105 MemRCol2105 10000.000000
R12171 MemRRow2171 MemRCol2171 10000.000000
R12238 MemRRow2238 MemRCol2238 10000.000000
R12306 MemRRow2306 MemRCol2306 10000.000000
R12375 MemRRow2375 MemRCol2375 10000.000000
R12445 MemRRow2445 MemRCol2445 10000.000000
R12516 MemRRow2516 MemRCol2516 10000.000000
R12588 MemRRow2588 MemRCol2588 10000.000000
R12661 MemRRow2661 MemRCol2661 10000.000000
R12735 MemRRow2735 MemRCol2735 10000.000000
R12810 MemRRow2810 MemRCol2810 10000.000000
R12886 MemRRow2886 MemRCol2886 10000.000000
R12963 MemRRow2963 MemRCol2963 10000.000000
R13041 MemRRow3041 MemRCol3041 10000.000000
R13120 MemRRow3120 MemRCol3120 10000.000000
R13200 MemRRow3200 MemRCol3200 10000.000000
R13281 MemRRow3281 MemRCol3281 10000.000000
R13363 MemRRow3363 MemRCol3363 10000.000000
R13446 MemRRow3446 MemRCol3446 10000.000000
R13530 MemRRow3530 MemRCol3530 10000.000000
R13615 MemRRow3615 MemRCol3615 10000.000000
R13701 MemRRow3701 MemRCol3701 10000.000000
R13788 MemRRow3788 MemRCol3788 10000.000000
R13876 MemRRow3876 MemRCol3876 10000.000000
R13965 MemRRow3965 MemRCol3965 10000.000000
R14055 MemRRow4055 MemRCol4055 10000.000000
R1862 MemRRow862 MemRCol862 10000.000000
R1905 MemRRow905 MemRCol905 10000.000000
R1949 MemRRow949 MemRCol949 10000.000000
R1994 MemRRow994 MemRCol994 10000.000000
R11040 MemRRow1040 MemRCol1040 10000.000000
R11087 MemRRow1087 MemRCol1087 10000.000000
R11135 MemRRow1135 MemRCol1135 10000.000000
R11184 MemRRow1184 MemRCol1184 10000.000000
R11234 MemRRow1234 MemRCol1234 10000.000000
R11285 MemRRow1285 MemRCol1285 10000.000000
R11337 MemRRow1337 MemRCol1337 10000.000000
R11390 MemRRow1390 MemRCol1390 10000.000000
R11444 MemRRow1444 MemRCol1444 10000.000000
R11499 MemRRow1499 MemRCol1499 10000.000000
R11555 MemRRow1555 MemRCol1555 10000.000000
R11612 MemRRow1612 MemRCol1612 10000.000000
R11670 MemRRow1670 MemRCol1670 10000.000000
R11729 MemRRow1729 MemRCol1729 10000.000000
R11789 MemRRow1789 MemRCol1789 10000.000000
R11850 MemRRow1850 MemRCol1850 10000.000000
R11912 MemRRow1912 MemRCol1912 10000.000000
R11975 MemRRow1975 MemRCol1975 10000.000000
R12039 MemRRow2039 MemRCol2039 10000.000000
R12104 MemRRow2104 MemRCol2104 10000.000000
R12170 MemRRow2170 MemRCol2170 10000.000000
R12237 MemRRow2237 MemRCol2237 10000.000000
R12305 MemRRow2305 MemRCol2305 10000.000000
R12374 MemRRow2374 MemRCol2374 10000.000000
R12444 MemRRow2444 MemRCol2444 10000.000000
R12515 MemRRow2515 MemRCol2515 10000.000000
R12587 MemRRow2587 MemRCol2587 10000.000000
R12660 MemRRow2660 MemRCol2660 10000.000000
R12734 MemRRow2734 MemRCol2734 10000.000000
R12809 MemRRow2809 MemRCol2809 10000.000000
R12885 MemRRow2885 MemRCol2885 10000.000000
R12962 MemRRow2962 MemRCol2962 10000.000000
R13040 MemRRow3040 MemRCol3040 10000.000000
R13119 MemRRow3119 MemRCol3119 10000.000000
R13199 MemRRow3199 MemRCol3199 10000.000000
R13280 MemRRow3280 MemRCol3280 10000.000000
R13362 MemRRow3362 MemRCol3362 10000.000000
R13445 MemRRow3445 MemRCol3445 10000.000000
R13529 MemRRow3529 MemRCol3529 10000.000000
R13614 MemRRow3614 MemRCol3614 10000.000000
R13700 MemRRow3700 MemRCol3700 10000.000000
R13787 MemRRow3787 MemRCol3787 10000.000000
R13875 MemRRow3875 MemRCol3875 10000.000000
R13964 MemRRow3964 MemRCol3964 10000.000000
R14054 MemRRow4054 MemRCol4054 10000.000000
R14145 MemRRow4145 MemRCol4145 10000.000000
R1904 MemRRow904 MemRCol904 10000.000000
R1948 MemRRow948 MemRCol948 10000.000000
R1993 MemRRow993 MemRCol993 10000.000000
R11039 MemRRow1039 MemRCol1039 10000.000000
R11086 MemRRow1086 MemRCol1086 10000.000000
R11134 MemRRow1134 MemRCol1134 10000.000000
R11183 MemRRow1183 MemRCol1183 10000.000000
R11233 MemRRow1233 MemRCol1233 10000.000000
R11284 MemRRow1284 MemRCol1284 10000.000000
R11336 MemRRow1336 MemRCol1336 10000.000000
R11389 MemRRow1389 MemRCol1389 10000.000000
R11443 MemRRow1443 MemRCol1443 10000.000000
R11498 MemRRow1498 MemRCol1498 10000.000000
R11554 MemRRow1554 MemRCol1554 10000.000000
R11611 MemRRow1611 MemRCol1611 10000.000000
R11669 MemRRow1669 MemRCol1669 10000.000000
R11728 MemRRow1728 MemRCol1728 10000.000000
R11788 MemRRow1788 MemRCol1788 10000.000000
R11849 MemRRow1849 MemRCol1849 10000.000000
R11911 MemRRow1911 MemRCol1911 10000.000000
R11974 MemRRow1974 MemRCol1974 10000.000000
R12038 MemRRow2038 MemRCol2038 10000.000000
R12103 MemRRow2103 MemRCol2103 10000.000000
R12169 MemRRow2169 MemRCol2169 10000.000000
R12236 MemRRow2236 MemRCol2236 10000.000000
R12304 MemRRow2304 MemRCol2304 10000.000000
R12373 MemRRow2373 MemRCol2373 10000.000000
R12443 MemRRow2443 MemRCol2443 10000.000000
R12514 MemRRow2514 MemRCol2514 10000.000000
R12586 MemRRow2586 MemRCol2586 10000.000000
R12659 MemRRow2659 MemRCol2659 10000.000000
R12733 MemRRow2733 MemRCol2733 10000.000000
R12808 MemRRow2808 MemRCol2808 10000.000000
R12884 MemRRow2884 MemRCol2884 10000.000000
R12961 MemRRow2961 MemRCol2961 10000.000000
R13039 MemRRow3039 MemRCol3039 10000.000000
R13118 MemRRow3118 MemRCol3118 10000.000000
R13198 MemRRow3198 MemRCol3198 10000.000000
R13279 MemRRow3279 MemRCol3279 10000.000000
R13361 MemRRow3361 MemRCol3361 10000.000000
R13444 MemRRow3444 MemRCol3444 10000.000000
R13528 MemRRow3528 MemRCol3528 10000.000000
R13613 MemRRow3613 MemRCol3613 10000.000000
R13699 MemRRow3699 MemRCol3699 10000.000000
R13786 MemRRow3786 MemRCol3786 10000.000000
R13874 MemRRow3874 MemRCol3874 10000.000000
R13963 MemRRow3963 MemRCol3963 10000.000000
R14053 MemRRow4053 MemRCol4053 10000.000000
R14144 MemRRow4144 MemRCol4144 10000.000000
R14236 MemRRow4236 MemRCol4236 10000.000000
R1947 MemRRow947 MemRCol947 10000.000000
R1992 MemRRow992 MemRCol992 10000.000000
R11038 MemRRow1038 MemRCol1038 10000.000000
R11085 MemRRow1085 MemRCol1085 10000.000000
R11133 MemRRow1133 MemRCol1133 10000.000000
R11182 MemRRow1182 MemRCol1182 10000.000000
R11232 MemRRow1232 MemRCol1232 10000.000000
R11283 MemRRow1283 MemRCol1283 10000.000000
R11335 MemRRow1335 MemRCol1335 10000.000000
R11388 MemRRow1388 MemRCol1388 10000.000000
R11442 MemRRow1442 MemRCol1442 10000.000000
R11497 MemRRow1497 MemRCol1497 10000.000000
R11553 MemRRow1553 MemRCol1553 10000.000000
R11610 MemRRow1610 MemRCol1610 10000.000000
R11668 MemRRow1668 MemRCol1668 10000.000000
R11727 MemRRow1727 MemRCol1727 10000.000000
R11787 MemRRow1787 MemRCol1787 10000.000000
R11848 MemRRow1848 MemRCol1848 10000.000000
R11910 MemRRow1910 MemRCol1910 10000.000000
R11973 MemRRow1973 MemRCol1973 10000.000000
R12037 MemRRow2037 MemRCol2037 10000.000000
R12102 MemRRow2102 MemRCol2102 10000.000000
R12168 MemRRow2168 MemRCol2168 10000.000000
R12235 MemRRow2235 MemRCol2235 10000.000000
R12303 MemRRow2303 MemRCol2303 10000.000000
R12372 MemRRow2372 MemRCol2372 10000.000000
R12442 MemRRow2442 MemRCol2442 10000.000000
R12513 MemRRow2513 MemRCol2513 10000.000000
R12585 MemRRow2585 MemRCol2585 10000.000000
R12658 MemRRow2658 MemRCol2658 10000.000000
R12732 MemRRow2732 MemRCol2732 10000.000000
R12807 MemRRow2807 MemRCol2807 10000.000000
R12883 MemRRow2883 MemRCol2883 10000.000000
R12960 MemRRow2960 MemRCol2960 10000.000000
R13038 MemRRow3038 MemRCol3038 10000.000000
R13117 MemRRow3117 MemRCol3117 10000.000000
R13197 MemRRow3197 MemRCol3197 10000.000000
R13278 MemRRow3278 MemRCol3278 10000.000000
R13360 MemRRow3360 MemRCol3360 10000.000000
R13443 MemRRow3443 MemRCol3443 10000.000000
R13527 MemRRow3527 MemRCol3527 10000.000000
R13612 MemRRow3612 MemRCol3612 10000.000000
R13698 MemRRow3698 MemRCol3698 10000.000000
R13785 MemRRow3785 MemRCol3785 10000.000000
R13873 MemRRow3873 MemRCol3873 10000.000000
R13962 MemRRow3962 MemRCol3962 10000.000000
R14052 MemRRow4052 MemRCol4052 10000.000000
R14143 MemRRow4143 MemRCol4143 10000.000000
R14235 MemRRow4235 MemRCol4235 10000.000000
R14328 MemRRow4328 MemRCol4328 10000.000000
R1991 MemRRow991 MemRCol991 10000.000000
R11037 MemRRow1037 MemRCol1037 10000.000000
R11084 MemRRow1084 MemRCol1084 10000.000000
R11132 MemRRow1132 MemRCol1132 10000.000000
R11181 MemRRow1181 MemRCol1181 10000.000000
R11231 MemRRow1231 MemRCol1231 10000.000000
R11282 MemRRow1282 MemRCol1282 10000.000000
R11334 MemRRow1334 MemRCol1334 10000.000000
R11387 MemRRow1387 MemRCol1387 10000.000000
R11441 MemRRow1441 MemRCol1441 10000.000000
R11496 MemRRow1496 MemRCol1496 10000.000000
R11552 MemRRow1552 MemRCol1552 10000.000000
R11609 MemRRow1609 MemRCol1609 10000.000000
R11667 MemRRow1667 MemRCol1667 10000.000000
R11726 MemRRow1726 MemRCol1726 10000.000000
R11786 MemRRow1786 MemRCol1786 10000.000000
R11847 MemRRow1847 MemRCol1847 10000.000000
R11909 MemRRow1909 MemRCol1909 10000.000000
R11972 MemRRow1972 MemRCol1972 10000.000000
R12036 MemRRow2036 MemRCol2036 10000.000000
R12101 MemRRow2101 MemRCol2101 10000.000000
R12167 MemRRow2167 MemRCol2167 10000.000000
R12234 MemRRow2234 MemRCol2234 10000.000000
R12302 MemRRow2302 MemRCol2302 10000.000000
R12371 MemRRow2371 MemRCol2371 10000.000000
R12441 MemRRow2441 MemRCol2441 10000.000000
R12512 MemRRow2512 MemRCol2512 10000.000000
R12584 MemRRow2584 MemRCol2584 10000.000000
R12657 MemRRow2657 MemRCol2657 10000.000000
R12731 MemRRow2731 MemRCol2731 10000.000000
R12806 MemRRow2806 MemRCol2806 10000.000000
R12882 MemRRow2882 MemRCol2882 10000.000000
R12959 MemRRow2959 MemRCol2959 10000.000000
R13037 MemRRow3037 MemRCol3037 10000.000000
R13116 MemRRow3116 MemRCol3116 10000.000000
R13196 MemRRow3196 MemRCol3196 10000.000000
R13277 MemRRow3277 MemRCol3277 10000.000000
R13359 MemRRow3359 MemRCol3359 10000.000000
R13442 MemRRow3442 MemRCol3442 10000.000000
R13526 MemRRow3526 MemRCol3526 10000.000000
R13611 MemRRow3611 MemRCol3611 10000.000000
R13697 MemRRow3697 MemRCol3697 10000.000000
R13784 MemRRow3784 MemRCol3784 10000.000000
R13872 MemRRow3872 MemRCol3872 10000.000000
R13961 MemRRow3961 MemRCol3961 10000.000000
R14051 MemRRow4051 MemRCol4051 10000.000000
R14142 MemRRow4142 MemRCol4142 10000.000000
R14234 MemRRow4234 MemRCol4234 10000.000000
R14327 MemRRow4327 MemRCol4327 10000.000000
R14421 MemRRow4421 MemRCol4421 10000.000000
R11036 MemRRow1036 MemRCol1036 10000.000000
R11083 MemRRow1083 MemRCol1083 10000.000000
R11131 MemRRow1131 MemRCol1131 10000.000000
R11180 MemRRow1180 MemRCol1180 10000.000000
R11230 MemRRow1230 MemRCol1230 10000.000000
R11281 MemRRow1281 MemRCol1281 10000.000000
R11333 MemRRow1333 MemRCol1333 10000.000000
R11386 MemRRow1386 MemRCol1386 10000.000000
R11440 MemRRow1440 MemRCol1440 10000.000000
R11495 MemRRow1495 MemRCol1495 10000.000000
R11551 MemRRow1551 MemRCol1551 10000.000000
R11608 MemRRow1608 MemRCol1608 10000.000000
R11666 MemRRow1666 MemRCol1666 10000.000000
R11725 MemRRow1725 MemRCol1725 10000.000000
R11785 MemRRow1785 MemRCol1785 10000.000000
R11846 MemRRow1846 MemRCol1846 10000.000000
R11908 MemRRow1908 MemRCol1908 10000.000000
R11971 MemRRow1971 MemRCol1971 10000.000000
R12035 MemRRow2035 MemRCol2035 10000.000000
R12100 MemRRow2100 MemRCol2100 10000.000000
R12166 MemRRow2166 MemRCol2166 10000.000000
R12233 MemRRow2233 MemRCol2233 10000.000000
R12301 MemRRow2301 MemRCol2301 10000.000000
R12370 MemRRow2370 MemRCol2370 10000.000000
R12440 MemRRow2440 MemRCol2440 10000.000000
R12511 MemRRow2511 MemRCol2511 10000.000000
R12583 MemRRow2583 MemRCol2583 10000.000000
R12656 MemRRow2656 MemRCol2656 10000.000000
R12730 MemRRow2730 MemRCol2730 10000.000000
R12805 MemRRow2805 MemRCol2805 10000.000000
R12881 MemRRow2881 MemRCol2881 10000.000000
R12958 MemRRow2958 MemRCol2958 10000.000000
R13036 MemRRow3036 MemRCol3036 10000.000000
R13115 MemRRow3115 MemRCol3115 10000.000000
R13195 MemRRow3195 MemRCol3195 10000.000000
R13276 MemRRow3276 MemRCol3276 10000.000000
R13358 MemRRow3358 MemRCol3358 10000.000000
R13441 MemRRow3441 MemRCol3441 10000.000000
R13525 MemRRow3525 MemRCol3525 10000.000000
R13610 MemRRow3610 MemRCol3610 10000.000000
R13696 MemRRow3696 MemRCol3696 10000.000000
R13783 MemRRow3783 MemRCol3783 10000.000000
R13871 MemRRow3871 MemRCol3871 10000.000000
R13960 MemRRow3960 MemRCol3960 10000.000000
R14050 MemRRow4050 MemRCol4050 10000.000000
R14141 MemRRow4141 MemRCol4141 10000.000000
R14233 MemRRow4233 MemRCol4233 10000.000000
R14326 MemRRow4326 MemRCol4326 10000.000000
R14420 MemRRow4420 MemRCol4420 10000.000000
R14515 MemRRow4515 MemRCol4515 10000.000000
R11082 MemRRow1082 MemRCol1082 10000.000000
R11130 MemRRow1130 MemRCol1130 10000.000000
R11179 MemRRow1179 MemRCol1179 10000.000000
R11229 MemRRow1229 MemRCol1229 10000.000000
R11280 MemRRow1280 MemRCol1280 10000.000000
R11332 MemRRow1332 MemRCol1332 10000.000000
R11385 MemRRow1385 MemRCol1385 10000.000000
R11439 MemRRow1439 MemRCol1439 10000.000000
R11494 MemRRow1494 MemRCol1494 10000.000000
R11550 MemRRow1550 MemRCol1550 10000.000000
R11607 MemRRow1607 MemRCol1607 10000.000000
R11665 MemRRow1665 MemRCol1665 10000.000000
R11724 MemRRow1724 MemRCol1724 10000.000000
R11784 MemRRow1784 MemRCol1784 10000.000000
R11845 MemRRow1845 MemRCol1845 10000.000000
R11907 MemRRow1907 MemRCol1907 10000.000000
R11970 MemRRow1970 MemRCol1970 10000.000000
R12034 MemRRow2034 MemRCol2034 10000.000000
R12099 MemRRow2099 MemRCol2099 10000.000000
R12165 MemRRow2165 MemRCol2165 10000.000000
R12232 MemRRow2232 MemRCol2232 10000.000000
R12300 MemRRow2300 MemRCol2300 10000.000000
R12369 MemRRow2369 MemRCol2369 10000.000000
R12439 MemRRow2439 MemRCol2439 10000.000000
R12510 MemRRow2510 MemRCol2510 10000.000000
R12582 MemRRow2582 MemRCol2582 10000.000000
R12655 MemRRow2655 MemRCol2655 10000.000000
R12729 MemRRow2729 MemRCol2729 10000.000000
R12804 MemRRow2804 MemRCol2804 10000.000000
R12880 MemRRow2880 MemRCol2880 10000.000000
R12957 MemRRow2957 MemRCol2957 10000.000000
R13035 MemRRow3035 MemRCol3035 10000.000000
R13114 MemRRow3114 MemRCol3114 10000.000000
R13194 MemRRow3194 MemRCol3194 10000.000000
R13275 MemRRow3275 MemRCol3275 10000.000000
R13357 MemRRow3357 MemRCol3357 10000.000000
R13440 MemRRow3440 MemRCol3440 10000.000000
R13524 MemRRow3524 MemRCol3524 10000.000000
R13609 MemRRow3609 MemRCol3609 10000.000000
R13695 MemRRow3695 MemRCol3695 10000.000000
R13782 MemRRow3782 MemRCol3782 10000.000000
R13870 MemRRow3870 MemRCol3870 10000.000000
R13959 MemRRow3959 MemRCol3959 10000.000000
R14049 MemRRow4049 MemRCol4049 10000.000000
R14140 MemRRow4140 MemRCol4140 10000.000000
R14232 MemRRow4232 MemRCol4232 10000.000000
R14325 MemRRow4325 MemRCol4325 10000.000000
R14419 MemRRow4419 MemRCol4419 10000.000000
R14514 MemRRow4514 MemRCol4514 10000.000000
R14610 MemRRow4610 MemRCol4610 10000.000000
R11129 MemRRow1129 MemRCol1129 10000.000000
R11178 MemRRow1178 MemRCol1178 10000.000000
R11228 MemRRow1228 MemRCol1228 10000.000000
R11279 MemRRow1279 MemRCol1279 10000.000000
R11331 MemRRow1331 MemRCol1331 10000.000000
R11384 MemRRow1384 MemRCol1384 10000.000000
R11438 MemRRow1438 MemRCol1438 10000.000000
R11493 MemRRow1493 MemRCol1493 10000.000000
R11549 MemRRow1549 MemRCol1549 10000.000000
R11606 MemRRow1606 MemRCol1606 10000.000000
R11664 MemRRow1664 MemRCol1664 10000.000000
R11723 MemRRow1723 MemRCol1723 10000.000000
R11783 MemRRow1783 MemRCol1783 10000.000000
R11844 MemRRow1844 MemRCol1844 10000.000000
R11906 MemRRow1906 MemRCol1906 10000.000000
R11969 MemRRow1969 MemRCol1969 10000.000000
R12033 MemRRow2033 MemRCol2033 10000.000000
R12098 MemRRow2098 MemRCol2098 10000.000000
R12164 MemRRow2164 MemRCol2164 10000.000000
R12231 MemRRow2231 MemRCol2231 10000.000000
R12299 MemRRow2299 MemRCol2299 10000.000000
R12368 MemRRow2368 MemRCol2368 10000.000000
R12438 MemRRow2438 MemRCol2438 10000.000000
R12509 MemRRow2509 MemRCol2509 10000.000000
R12581 MemRRow2581 MemRCol2581 10000.000000
R12654 MemRRow2654 MemRCol2654 10000.000000
R12728 MemRRow2728 MemRCol2728 10000.000000
R12803 MemRRow2803 MemRCol2803 10000.000000
R12879 MemRRow2879 MemRCol2879 10000.000000
R12956 MemRRow2956 MemRCol2956 10000.000000
R13034 MemRRow3034 MemRCol3034 10000.000000
R13113 MemRRow3113 MemRCol3113 10000.000000
R13193 MemRRow3193 MemRCol3193 10000.000000
R13274 MemRRow3274 MemRCol3274 10000.000000
R13356 MemRRow3356 MemRCol3356 10000.000000
R13439 MemRRow3439 MemRCol3439 10000.000000
R13523 MemRRow3523 MemRCol3523 10000.000000
R13608 MemRRow3608 MemRCol3608 10000.000000
R13694 MemRRow3694 MemRCol3694 10000.000000
R13781 MemRRow3781 MemRCol3781 10000.000000
R13869 MemRRow3869 MemRCol3869 10000.000000
R13958 MemRRow3958 MemRCol3958 10000.000000
R14048 MemRRow4048 MemRCol4048 10000.000000
R14139 MemRRow4139 MemRCol4139 10000.000000
R14231 MemRRow4231 MemRCol4231 10000.000000
R14324 MemRRow4324 MemRCol4324 10000.000000
R14418 MemRRow4418 MemRCol4418 10000.000000
R14513 MemRRow4513 MemRCol4513 10000.000000
R14609 MemRRow4609 MemRCol4609 10000.000000
R14706 MemRRow4706 MemRCol4706 10000.000000
R11177 MemRRow1177 MemRCol1177 10000.000000
R11227 MemRRow1227 MemRCol1227 10000.000000
R11278 MemRRow1278 MemRCol1278 10000.000000
R11330 MemRRow1330 MemRCol1330 10000.000000
R11383 MemRRow1383 MemRCol1383 10000.000000
R11437 MemRRow1437 MemRCol1437 10000.000000
R11492 MemRRow1492 MemRCol1492 10000.000000
R11548 MemRRow1548 MemRCol1548 10000.000000
R11605 MemRRow1605 MemRCol1605 10000.000000
R11663 MemRRow1663 MemRCol1663 10000.000000
R11722 MemRRow1722 MemRCol1722 10000.000000
R11782 MemRRow1782 MemRCol1782 10000.000000
R11843 MemRRow1843 MemRCol1843 10000.000000
R11905 MemRRow1905 MemRCol1905 10000.000000
R11968 MemRRow1968 MemRCol1968 10000.000000
R12032 MemRRow2032 MemRCol2032 10000.000000
R12097 MemRRow2097 MemRCol2097 10000.000000
R12163 MemRRow2163 MemRCol2163 10000.000000
R12230 MemRRow2230 MemRCol2230 10000.000000
R12298 MemRRow2298 MemRCol2298 10000.000000
R12367 MemRRow2367 MemRCol2367 10000.000000
R12437 MemRRow2437 MemRCol2437 10000.000000
R12508 MemRRow2508 MemRCol2508 10000.000000
R12580 MemRRow2580 MemRCol2580 10000.000000
R12653 MemRRow2653 MemRCol2653 10000.000000
R12727 MemRRow2727 MemRCol2727 10000.000000
R12802 MemRRow2802 MemRCol2802 10000.000000
R12878 MemRRow2878 MemRCol2878 10000.000000
R12955 MemRRow2955 MemRCol2955 10000.000000
R13033 MemRRow3033 MemRCol3033 10000.000000
R13112 MemRRow3112 MemRCol3112 10000.000000
R13192 MemRRow3192 MemRCol3192 10000.000000
R13273 MemRRow3273 MemRCol3273 10000.000000
R13355 MemRRow3355 MemRCol3355 10000.000000
R13438 MemRRow3438 MemRCol3438 10000.000000
R13522 MemRRow3522 MemRCol3522 10000.000000
R13607 MemRRow3607 MemRCol3607 10000.000000
R13693 MemRRow3693 MemRCol3693 10000.000000
R13780 MemRRow3780 MemRCol3780 10000.000000
R13868 MemRRow3868 MemRCol3868 10000.000000
R13957 MemRRow3957 MemRCol3957 10000.000000
R14047 MemRRow4047 MemRCol4047 10000.000000
R14138 MemRRow4138 MemRCol4138 10000.000000
R14230 MemRRow4230 MemRCol4230 10000.000000
R14323 MemRRow4323 MemRCol4323 10000.000000
R14417 MemRRow4417 MemRCol4417 10000.000000
R14512 MemRRow4512 MemRCol4512 10000.000000
R14608 MemRRow4608 MemRCol4608 10000.000000
R14705 MemRRow4705 MemRCol4705 10000.000000
R14803 MemRRow4803 MemRCol4803 10000.000000
R11226 MemRRow1226 MemRCol1226 10000.000000
R11277 MemRRow1277 MemRCol1277 10000.000000
R11329 MemRRow1329 MemRCol1329 10000.000000
R11382 MemRRow1382 MemRCol1382 10000.000000
R11436 MemRRow1436 MemRCol1436 10000.000000
R11491 MemRRow1491 MemRCol1491 10000.000000
R11547 MemRRow1547 MemRCol1547 10000.000000
R11604 MemRRow1604 MemRCol1604 10000.000000
R11662 MemRRow1662 MemRCol1662 10000.000000
R11721 MemRRow1721 MemRCol1721 10000.000000
R11781 MemRRow1781 MemRCol1781 10000.000000
R11842 MemRRow1842 MemRCol1842 10000.000000
R11904 MemRRow1904 MemRCol1904 10000.000000
R11967 MemRRow1967 MemRCol1967 10000.000000
R12031 MemRRow2031 MemRCol2031 10000.000000
R12096 MemRRow2096 MemRCol2096 10000.000000
R12162 MemRRow2162 MemRCol2162 10000.000000
R12229 MemRRow2229 MemRCol2229 10000.000000
R12297 MemRRow2297 MemRCol2297 10000.000000
R12366 MemRRow2366 MemRCol2366 10000.000000
R12436 MemRRow2436 MemRCol2436 10000.000000
R12507 MemRRow2507 MemRCol2507 10000.000000
R12579 MemRRow2579 MemRCol2579 10000.000000
R12652 MemRRow2652 MemRCol2652 10000.000000
R12726 MemRRow2726 MemRCol2726 10000.000000
R12801 MemRRow2801 MemRCol2801 10000.000000
R12877 MemRRow2877 MemRCol2877 10000.000000
R12954 MemRRow2954 MemRCol2954 10000.000000
R13032 MemRRow3032 MemRCol3032 10000.000000
R13111 MemRRow3111 MemRCol3111 10000.000000
R13191 MemRRow3191 MemRCol3191 10000.000000
R13272 MemRRow3272 MemRCol3272 10000.000000
R13354 MemRRow3354 MemRCol3354 10000.000000
R13437 MemRRow3437 MemRCol3437 10000.000000
R13521 MemRRow3521 MemRCol3521 10000.000000
R13606 MemRRow3606 MemRCol3606 10000.000000
R13692 MemRRow3692 MemRCol3692 10000.000000
R13779 MemRRow3779 MemRCol3779 10000.000000
R13867 MemRRow3867 MemRCol3867 10000.000000
R13956 MemRRow3956 MemRCol3956 10000.000000
R14046 MemRRow4046 MemRCol4046 10000.000000
R14137 MemRRow4137 MemRCol4137 10000.000000
R14229 MemRRow4229 MemRCol4229 10000.000000
R14322 MemRRow4322 MemRCol4322 10000.000000
R14416 MemRRow4416 MemRCol4416 10000.000000
R14511 MemRRow4511 MemRCol4511 10000.000000
R14607 MemRRow4607 MemRCol4607 10000.000000
R14704 MemRRow4704 MemRCol4704 10000.000000
R14802 MemRRow4802 MemRCol4802 10000.000000
R14901 MemRRow4901 MemRCol4901 10000.000000
R11276 MemRRow1276 MemRCol1276 10000.000000
R11328 MemRRow1328 MemRCol1328 10000.000000
R11381 MemRRow1381 MemRCol1381 10000.000000
R11435 MemRRow1435 MemRCol1435 10000.000000
R11490 MemRRow1490 MemRCol1490 10000.000000
R11546 MemRRow1546 MemRCol1546 10000.000000
R11603 MemRRow1603 MemRCol1603 10000.000000
R11661 MemRRow1661 MemRCol1661 10000.000000
R11720 MemRRow1720 MemRCol1720 10000.000000
R11780 MemRRow1780 MemRCol1780 10000.000000
R11841 MemRRow1841 MemRCol1841 10000.000000
R11903 MemRRow1903 MemRCol1903 10000.000000
R11966 MemRRow1966 MemRCol1966 10000.000000
R12030 MemRRow2030 MemRCol2030 10000.000000
R12095 MemRRow2095 MemRCol2095 10000.000000
R12161 MemRRow2161 MemRCol2161 10000.000000
R12228 MemRRow2228 MemRCol2228 10000.000000
R12296 MemRRow2296 MemRCol2296 10000.000000
R12365 MemRRow2365 MemRCol2365 10000.000000
R12435 MemRRow2435 MemRCol2435 10000.000000
R12506 MemRRow2506 MemRCol2506 10000.000000
R12578 MemRRow2578 MemRCol2578 10000.000000
R12651 MemRRow2651 MemRCol2651 10000.000000
R12725 MemRRow2725 MemRCol2725 10000.000000
R12800 MemRRow2800 MemRCol2800 10000.000000
R12876 MemRRow2876 MemRCol2876 10000.000000
R12953 MemRRow2953 MemRCol2953 10000.000000
R13031 MemRRow3031 MemRCol3031 10000.000000
R13110 MemRRow3110 MemRCol3110 10000.000000
R13190 MemRRow3190 MemRCol3190 10000.000000
R13271 MemRRow3271 MemRCol3271 10000.000000
R13353 MemRRow3353 MemRCol3353 10000.000000
R13436 MemRRow3436 MemRCol3436 10000.000000
R13520 MemRRow3520 MemRCol3520 10000.000000
R13605 MemRRow3605 MemRCol3605 10000.000000
R13691 MemRRow3691 MemRCol3691 10000.000000
R13778 MemRRow3778 MemRCol3778 10000.000000
R13866 MemRRow3866 MemRCol3866 10000.000000
R13955 MemRRow3955 MemRCol3955 10000.000000
R14045 MemRRow4045 MemRCol4045 10000.000000
R14136 MemRRow4136 MemRCol4136 10000.000000
R14228 MemRRow4228 MemRCol4228 10000.000000
R14321 MemRRow4321 MemRCol4321 10000.000000
R14415 MemRRow4415 MemRCol4415 10000.000000
R14510 MemRRow4510 MemRCol4510 10000.000000
R14606 MemRRow4606 MemRCol4606 10000.000000
R14703 MemRRow4703 MemRCol4703 10000.000000
R14801 MemRRow4801 MemRCol4801 10000.000000
R14900 MemRRow4900 MemRCol4900 10000.000000
R15000 MemRRow5000 MemRCol5000 10000.000000
R11327 MemRRow1327 MemRCol1327 10000.000000
R11380 MemRRow1380 MemRCol1380 10000.000000
R11434 MemRRow1434 MemRCol1434 10000.000000
R11489 MemRRow1489 MemRCol1489 10000.000000
R11545 MemRRow1545 MemRCol1545 10000.000000
R11602 MemRRow1602 MemRCol1602 10000.000000
R11660 MemRRow1660 MemRCol1660 10000.000000
R11719 MemRRow1719 MemRCol1719 10000.000000
R11779 MemRRow1779 MemRCol1779 10000.000000
R11840 MemRRow1840 MemRCol1840 10000.000000
R11902 MemRRow1902 MemRCol1902 10000.000000
R11965 MemRRow1965 MemRCol1965 10000.000000
R12029 MemRRow2029 MemRCol2029 10000.000000
R12094 MemRRow2094 MemRCol2094 10000.000000
R12160 MemRRow2160 MemRCol2160 10000.000000
R12227 MemRRow2227 MemRCol2227 10000.000000
R12295 MemRRow2295 MemRCol2295 10000.000000
R12364 MemRRow2364 MemRCol2364 10000.000000
R12434 MemRRow2434 MemRCol2434 10000.000000
R12505 MemRRow2505 MemRCol2505 10000.000000
R12577 MemRRow2577 MemRCol2577 10000.000000
R12650 MemRRow2650 MemRCol2650 10000.000000
R12724 MemRRow2724 MemRCol2724 10000.000000
R12799 MemRRow2799 MemRCol2799 10000.000000
R12875 MemRRow2875 MemRCol2875 10000.000000
R12952 MemRRow2952 MemRCol2952 10000.000000
R13030 MemRRow3030 MemRCol3030 10000.000000
R13109 MemRRow3109 MemRCol3109 10000.000000
R13189 MemRRow3189 MemRCol3189 10000.000000
R13270 MemRRow3270 MemRCol3270 10000.000000
R13352 MemRRow3352 MemRCol3352 10000.000000
R13435 MemRRow3435 MemRCol3435 10000.000000
R13519 MemRRow3519 MemRCol3519 10000.000000
R13604 MemRRow3604 MemRCol3604 10000.000000
R13690 MemRRow3690 MemRCol3690 10000.000000
R13777 MemRRow3777 MemRCol3777 10000.000000
R13865 MemRRow3865 MemRCol3865 10000.000000
R13954 MemRRow3954 MemRCol3954 10000.000000
R14044 MemRRow4044 MemRCol4044 10000.000000
R14135 MemRRow4135 MemRCol4135 10000.000000
R14227 MemRRow4227 MemRCol4227 10000.000000
R14320 MemRRow4320 MemRCol4320 10000.000000
R14414 MemRRow4414 MemRCol4414 10000.000000
R14509 MemRRow4509 MemRCol4509 10000.000000
R14605 MemRRow4605 MemRCol4605 10000.000000
R14702 MemRRow4702 MemRCol4702 10000.000000
R14800 MemRRow4800 MemRCol4800 10000.000000
R14899 MemRRow4899 MemRCol4899 10000.000000
R14999 MemRRow4999 MemRCol4999 10000.000000
R15100 MemRRow5100 MemRCol5100 10000.000000

*Line Row Resistances
R24 MemRRow4 MemRRow8 1000.000000
R28 MemRRow8 MemRRow13 1000.000000
R213 MemRRow13 MemRRow19 1000.000000
R219 MemRRow19 MemRRow26 1000.000000
R226 MemRRow26 MemRRow34 1000.000000
R234 MemRRow34 MemRRow43 1000.000000
R243 MemRRow43 MemRRow53 1000.000000
R253 MemRRow53 MemRRow64 1000.000000
R264 MemRRow64 MemRRow76 1000.000000
R276 MemRRow76 MemRRow89 1000.000000
R289 MemRRow89 MemRRow103 1000.000000
R2103 MemRRow103 MemRRow118 1000.000000
R2118 MemRRow118 MemRRow134 1000.000000
R2134 MemRRow134 MemRRow151 1000.000000
R2151 MemRRow151 MemRRow169 1000.000000
R2169 MemRRow169 MemRRow188 1000.000000
R2188 MemRRow188 MemRRow208 1000.000000
R2208 MemRRow208 MemRRow229 1000.000000
R2229 MemRRow229 MemRRow251 1000.000000
R2251 MemRRow251 MemRRow274 1000.000000
R2274 MemRRow274 MemRRow298 1000.000000
R2298 MemRRow298 MemRRow323 1000.000000
R2323 MemRRow323 MemRRow349 1000.000000
R2349 MemRRow349 MemRRow376 1000.000000
R2376 MemRRow376 MemRRow404 1000.000000
R2404 MemRRow404 MemRRow433 1000.000000
R2433 MemRRow433 MemRRow463 1000.000000
R2463 MemRRow463 MemRRow494 1000.000000
R2494 MemRRow494 MemRRow526 1000.000000
R2526 MemRRow526 MemRRow559 1000.000000
R2559 MemRRow559 MemRRow593 1000.000000
R2593 MemRRow593 MemRRow628 1000.000000
R2628 MemRRow628 MemRRow664 1000.000000
R2664 MemRRow664 MemRRow701 1000.000000
R2701 MemRRow701 MemRRow739 1000.000000
R2739 MemRRow739 MemRRow778 1000.000000
R2778 MemRRow778 MemRRow818 1000.000000
R2818 MemRRow818 MemRRow859 1000.000000
R2859 MemRRow859 MemRRow901 1000.000000
R2901 MemRRow901 MemRRow944 1000.000000
R2944 MemRRow944 MemRRow988 1000.000000
R2988 MemRRow988 MemRRow1033 1000.000000
R21033 MemRRow1033 MemRRow1079 1000.000000
R21079 MemRRow1079 MemRRow1126 1000.000000
R21126 MemRRow1126 MemRRow1174 1000.000000
R21174 MemRRow1174 MemRRow1223 1000.000000
R21223 MemRRow1223 MemRRow1273 1000.000000
R21273 MemRRow1273 MemRRow1324 1000.000000
R21324 MemRRow1324 MemRRow1376 1000.000000
R21376 MemRRow1376 MemRRow1429 1000.000000
R27 MemRRow7 MemRRow12 1000.000000
R212 MemRRow12 MemRRow18 1000.000000
R218 MemRRow18 MemRRow25 1000.000000
R225 MemRRow25 MemRRow33 1000.000000
R233 MemRRow33 MemRRow42 1000.000000
R242 MemRRow42 MemRRow52 1000.000000
R252 MemRRow52 MemRRow63 1000.000000
R263 MemRRow63 MemRRow75 1000.000000
R275 MemRRow75 MemRRow88 1000.000000
R288 MemRRow88 MemRRow102 1000.000000
R2102 MemRRow102 MemRRow117 1000.000000
R2117 MemRRow117 MemRRow133 1000.000000
R2133 MemRRow133 MemRRow150 1000.000000
R2150 MemRRow150 MemRRow168 1000.000000
R2168 MemRRow168 MemRRow187 1000.000000
R2187 MemRRow187 MemRRow207 1000.000000
R2207 MemRRow207 MemRRow228 1000.000000
R2228 MemRRow228 MemRRow250 1000.000000
R2250 MemRRow250 MemRRow273 1000.000000
R2273 MemRRow273 MemRRow297 1000.000000
R2297 MemRRow297 MemRRow322 1000.000000
R2322 MemRRow322 MemRRow348 1000.000000
R2348 MemRRow348 MemRRow375 1000.000000
R2375 MemRRow375 MemRRow403 1000.000000
R2403 MemRRow403 MemRRow432 1000.000000
R2432 MemRRow432 MemRRow462 1000.000000
R2462 MemRRow462 MemRRow493 1000.000000
R2493 MemRRow493 MemRRow525 1000.000000
R2525 MemRRow525 MemRRow558 1000.000000
R2558 MemRRow558 MemRRow592 1000.000000
R2592 MemRRow592 MemRRow627 1000.000000
R2627 MemRRow627 MemRRow663 1000.000000
R2663 MemRRow663 MemRRow700 1000.000000
R2700 MemRRow700 MemRRow738 1000.000000
R2738 MemRRow738 MemRRow777 1000.000000
R2777 MemRRow777 MemRRow817 1000.000000
R2817 MemRRow817 MemRRow858 1000.000000
R2858 MemRRow858 MemRRow900 1000.000000
R2900 MemRRow900 MemRRow943 1000.000000
R2943 MemRRow943 MemRRow987 1000.000000
R2987 MemRRow987 MemRRow1032 1000.000000
R21032 MemRRow1032 MemRRow1078 1000.000000
R21078 MemRRow1078 MemRRow1125 1000.000000
R21125 MemRRow1125 MemRRow1173 1000.000000
R21173 MemRRow1173 MemRRow1222 1000.000000
R21222 MemRRow1222 MemRRow1272 1000.000000
R21272 MemRRow1272 MemRRow1323 1000.000000
R21323 MemRRow1323 MemRRow1375 1000.000000
R21375 MemRRow1375 MemRRow1428 1000.000000
R21428 MemRRow1428 MemRRow1482 1000.000000
R211 MemRRow11 MemRRow17 1000.000000
R217 MemRRow17 MemRRow24 1000.000000
R224 MemRRow24 MemRRow32 1000.000000
R232 MemRRow32 MemRRow41 1000.000000
R241 MemRRow41 MemRRow51 1000.000000
R251 MemRRow51 MemRRow62 1000.000000
R262 MemRRow62 MemRRow74 1000.000000
R274 MemRRow74 MemRRow87 1000.000000
R287 MemRRow87 MemRRow101 1000.000000
R2101 MemRRow101 MemRRow116 1000.000000
R2116 MemRRow116 MemRRow132 1000.000000
R2132 MemRRow132 MemRRow149 1000.000000
R2149 MemRRow149 MemRRow167 1000.000000
R2167 MemRRow167 MemRRow186 1000.000000
R2186 MemRRow186 MemRRow206 1000.000000
R2206 MemRRow206 MemRRow227 1000.000000
R2227 MemRRow227 MemRRow249 1000.000000
R2249 MemRRow249 MemRRow272 1000.000000
R2272 MemRRow272 MemRRow296 1000.000000
R2296 MemRRow296 MemRRow321 1000.000000
R2321 MemRRow321 MemRRow347 1000.000000
R2347 MemRRow347 MemRRow374 1000.000000
R2374 MemRRow374 MemRRow402 1000.000000
R2402 MemRRow402 MemRRow431 1000.000000
R2431 MemRRow431 MemRRow461 1000.000000
R2461 MemRRow461 MemRRow492 1000.000000
R2492 MemRRow492 MemRRow524 1000.000000
R2524 MemRRow524 MemRRow557 1000.000000
R2557 MemRRow557 MemRRow591 1000.000000
R2591 MemRRow591 MemRRow626 1000.000000
R2626 MemRRow626 MemRRow662 1000.000000
R2662 MemRRow662 MemRRow699 1000.000000
R2699 MemRRow699 MemRRow737 1000.000000
R2737 MemRRow737 MemRRow776 1000.000000
R2776 MemRRow776 MemRRow816 1000.000000
R2816 MemRRow816 MemRRow857 1000.000000
R2857 MemRRow857 MemRRow899 1000.000000
R2899 MemRRow899 MemRRow942 1000.000000
R2942 MemRRow942 MemRRow986 1000.000000
R2986 MemRRow986 MemRRow1031 1000.000000
R21031 MemRRow1031 MemRRow1077 1000.000000
R21077 MemRRow1077 MemRRow1124 1000.000000
R21124 MemRRow1124 MemRRow1172 1000.000000
R21172 MemRRow1172 MemRRow1221 1000.000000
R21221 MemRRow1221 MemRRow1271 1000.000000
R21271 MemRRow1271 MemRRow1322 1000.000000
R21322 MemRRow1322 MemRRow1374 1000.000000
R21374 MemRRow1374 MemRRow1427 1000.000000
R21427 MemRRow1427 MemRRow1481 1000.000000
R21481 MemRRow1481 MemRRow1536 1000.000000
R216 MemRRow16 MemRRow23 1000.000000
R223 MemRRow23 MemRRow31 1000.000000
R231 MemRRow31 MemRRow40 1000.000000
R240 MemRRow40 MemRRow50 1000.000000
R250 MemRRow50 MemRRow61 1000.000000
R261 MemRRow61 MemRRow73 1000.000000
R273 MemRRow73 MemRRow86 1000.000000
R286 MemRRow86 MemRRow100 1000.000000
R2100 MemRRow100 MemRRow115 1000.000000
R2115 MemRRow115 MemRRow131 1000.000000
R2131 MemRRow131 MemRRow148 1000.000000
R2148 MemRRow148 MemRRow166 1000.000000
R2166 MemRRow166 MemRRow185 1000.000000
R2185 MemRRow185 MemRRow205 1000.000000
R2205 MemRRow205 MemRRow226 1000.000000
R2226 MemRRow226 MemRRow248 1000.000000
R2248 MemRRow248 MemRRow271 1000.000000
R2271 MemRRow271 MemRRow295 1000.000000
R2295 MemRRow295 MemRRow320 1000.000000
R2320 MemRRow320 MemRRow346 1000.000000
R2346 MemRRow346 MemRRow373 1000.000000
R2373 MemRRow373 MemRRow401 1000.000000
R2401 MemRRow401 MemRRow430 1000.000000
R2430 MemRRow430 MemRRow460 1000.000000
R2460 MemRRow460 MemRRow491 1000.000000
R2491 MemRRow491 MemRRow523 1000.000000
R2523 MemRRow523 MemRRow556 1000.000000
R2556 MemRRow556 MemRRow590 1000.000000
R2590 MemRRow590 MemRRow625 1000.000000
R2625 MemRRow625 MemRRow661 1000.000000
R2661 MemRRow661 MemRRow698 1000.000000
R2698 MemRRow698 MemRRow736 1000.000000
R2736 MemRRow736 MemRRow775 1000.000000
R2775 MemRRow775 MemRRow815 1000.000000
R2815 MemRRow815 MemRRow856 1000.000000
R2856 MemRRow856 MemRRow898 1000.000000
R2898 MemRRow898 MemRRow941 1000.000000
R2941 MemRRow941 MemRRow985 1000.000000
R2985 MemRRow985 MemRRow1030 1000.000000
R21030 MemRRow1030 MemRRow1076 1000.000000
R21076 MemRRow1076 MemRRow1123 1000.000000
R21123 MemRRow1123 MemRRow1171 1000.000000
R21171 MemRRow1171 MemRRow1220 1000.000000
R21220 MemRRow1220 MemRRow1270 1000.000000
R21270 MemRRow1270 MemRRow1321 1000.000000
R21321 MemRRow1321 MemRRow1373 1000.000000
R21373 MemRRow1373 MemRRow1426 1000.000000
R21426 MemRRow1426 MemRRow1480 1000.000000
R21480 MemRRow1480 MemRRow1535 1000.000000
R21535 MemRRow1535 MemRRow1591 1000.000000
R222 MemRRow22 MemRRow30 1000.000000
R230 MemRRow30 MemRRow39 1000.000000
R239 MemRRow39 MemRRow49 1000.000000
R249 MemRRow49 MemRRow60 1000.000000
R260 MemRRow60 MemRRow72 1000.000000
R272 MemRRow72 MemRRow85 1000.000000
R285 MemRRow85 MemRRow99 1000.000000
R299 MemRRow99 MemRRow114 1000.000000
R2114 MemRRow114 MemRRow130 1000.000000
R2130 MemRRow130 MemRRow147 1000.000000
R2147 MemRRow147 MemRRow165 1000.000000
R2165 MemRRow165 MemRRow184 1000.000000
R2184 MemRRow184 MemRRow204 1000.000000
R2204 MemRRow204 MemRRow225 1000.000000
R2225 MemRRow225 MemRRow247 1000.000000
R2247 MemRRow247 MemRRow270 1000.000000
R2270 MemRRow270 MemRRow294 1000.000000
R2294 MemRRow294 MemRRow319 1000.000000
R2319 MemRRow319 MemRRow345 1000.000000
R2345 MemRRow345 MemRRow372 1000.000000
R2372 MemRRow372 MemRRow400 1000.000000
R2400 MemRRow400 MemRRow429 1000.000000
R2429 MemRRow429 MemRRow459 1000.000000
R2459 MemRRow459 MemRRow490 1000.000000
R2490 MemRRow490 MemRRow522 1000.000000
R2522 MemRRow522 MemRRow555 1000.000000
R2555 MemRRow555 MemRRow589 1000.000000
R2589 MemRRow589 MemRRow624 1000.000000
R2624 MemRRow624 MemRRow660 1000.000000
R2660 MemRRow660 MemRRow697 1000.000000
R2697 MemRRow697 MemRRow735 1000.000000
R2735 MemRRow735 MemRRow774 1000.000000
R2774 MemRRow774 MemRRow814 1000.000000
R2814 MemRRow814 MemRRow855 1000.000000
R2855 MemRRow855 MemRRow897 1000.000000
R2897 MemRRow897 MemRRow940 1000.000000
R2940 MemRRow940 MemRRow984 1000.000000
R2984 MemRRow984 MemRRow1029 1000.000000
R21029 MemRRow1029 MemRRow1075 1000.000000
R21075 MemRRow1075 MemRRow1122 1000.000000
R21122 MemRRow1122 MemRRow1170 1000.000000
R21170 MemRRow1170 MemRRow1219 1000.000000
R21219 MemRRow1219 MemRRow1269 1000.000000
R21269 MemRRow1269 MemRRow1320 1000.000000
R21320 MemRRow1320 MemRRow1372 1000.000000
R21372 MemRRow1372 MemRRow1425 1000.000000
R21425 MemRRow1425 MemRRow1479 1000.000000
R21479 MemRRow1479 MemRRow1534 1000.000000
R21534 MemRRow1534 MemRRow1590 1000.000000
R21590 MemRRow1590 MemRRow1647 1000.000000
R229 MemRRow29 MemRRow38 1000.000000
R238 MemRRow38 MemRRow48 1000.000000
R248 MemRRow48 MemRRow59 1000.000000
R259 MemRRow59 MemRRow71 1000.000000
R271 MemRRow71 MemRRow84 1000.000000
R284 MemRRow84 MemRRow98 1000.000000
R298 MemRRow98 MemRRow113 1000.000000
R2113 MemRRow113 MemRRow129 1000.000000
R2129 MemRRow129 MemRRow146 1000.000000
R2146 MemRRow146 MemRRow164 1000.000000
R2164 MemRRow164 MemRRow183 1000.000000
R2183 MemRRow183 MemRRow203 1000.000000
R2203 MemRRow203 MemRRow224 1000.000000
R2224 MemRRow224 MemRRow246 1000.000000
R2246 MemRRow246 MemRRow269 1000.000000
R2269 MemRRow269 MemRRow293 1000.000000
R2293 MemRRow293 MemRRow318 1000.000000
R2318 MemRRow318 MemRRow344 1000.000000
R2344 MemRRow344 MemRRow371 1000.000000
R2371 MemRRow371 MemRRow399 1000.000000
R2399 MemRRow399 MemRRow428 1000.000000
R2428 MemRRow428 MemRRow458 1000.000000
R2458 MemRRow458 MemRRow489 1000.000000
R2489 MemRRow489 MemRRow521 1000.000000
R2521 MemRRow521 MemRRow554 1000.000000
R2554 MemRRow554 MemRRow588 1000.000000
R2588 MemRRow588 MemRRow623 1000.000000
R2623 MemRRow623 MemRRow659 1000.000000
R2659 MemRRow659 MemRRow696 1000.000000
R2696 MemRRow696 MemRRow734 1000.000000
R2734 MemRRow734 MemRRow773 1000.000000
R2773 MemRRow773 MemRRow813 1000.000000
R2813 MemRRow813 MemRRow854 1000.000000
R2854 MemRRow854 MemRRow896 1000.000000
R2896 MemRRow896 MemRRow939 1000.000000
R2939 MemRRow939 MemRRow983 1000.000000
R2983 MemRRow983 MemRRow1028 1000.000000
R21028 MemRRow1028 MemRRow1074 1000.000000
R21074 MemRRow1074 MemRRow1121 1000.000000
R21121 MemRRow1121 MemRRow1169 1000.000000
R21169 MemRRow1169 MemRRow1218 1000.000000
R21218 MemRRow1218 MemRRow1268 1000.000000
R21268 MemRRow1268 MemRRow1319 1000.000000
R21319 MemRRow1319 MemRRow1371 1000.000000
R21371 MemRRow1371 MemRRow1424 1000.000000
R21424 MemRRow1424 MemRRow1478 1000.000000
R21478 MemRRow1478 MemRRow1533 1000.000000
R21533 MemRRow1533 MemRRow1589 1000.000000
R21589 MemRRow1589 MemRRow1646 1000.000000
R21646 MemRRow1646 MemRRow1704 1000.000000
R237 MemRRow37 MemRRow47 1000.000000
R247 MemRRow47 MemRRow58 1000.000000
R258 MemRRow58 MemRRow70 1000.000000
R270 MemRRow70 MemRRow83 1000.000000
R283 MemRRow83 MemRRow97 1000.000000
R297 MemRRow97 MemRRow112 1000.000000
R2112 MemRRow112 MemRRow128 1000.000000
R2128 MemRRow128 MemRRow145 1000.000000
R2145 MemRRow145 MemRRow163 1000.000000
R2163 MemRRow163 MemRRow182 1000.000000
R2182 MemRRow182 MemRRow202 1000.000000
R2202 MemRRow202 MemRRow223 1000.000000
R2223 MemRRow223 MemRRow245 1000.000000
R2245 MemRRow245 MemRRow268 1000.000000
R2268 MemRRow268 MemRRow292 1000.000000
R2292 MemRRow292 MemRRow317 1000.000000
R2317 MemRRow317 MemRRow343 1000.000000
R2343 MemRRow343 MemRRow370 1000.000000
R2370 MemRRow370 MemRRow398 1000.000000
R2398 MemRRow398 MemRRow427 1000.000000
R2427 MemRRow427 MemRRow457 1000.000000
R2457 MemRRow457 MemRRow488 1000.000000
R2488 MemRRow488 MemRRow520 1000.000000
R2520 MemRRow520 MemRRow553 1000.000000
R2553 MemRRow553 MemRRow587 1000.000000
R2587 MemRRow587 MemRRow622 1000.000000
R2622 MemRRow622 MemRRow658 1000.000000
R2658 MemRRow658 MemRRow695 1000.000000
R2695 MemRRow695 MemRRow733 1000.000000
R2733 MemRRow733 MemRRow772 1000.000000
R2772 MemRRow772 MemRRow812 1000.000000
R2812 MemRRow812 MemRRow853 1000.000000
R2853 MemRRow853 MemRRow895 1000.000000
R2895 MemRRow895 MemRRow938 1000.000000
R2938 MemRRow938 MemRRow982 1000.000000
R2982 MemRRow982 MemRRow1027 1000.000000
R21027 MemRRow1027 MemRRow1073 1000.000000
R21073 MemRRow1073 MemRRow1120 1000.000000
R21120 MemRRow1120 MemRRow1168 1000.000000
R21168 MemRRow1168 MemRRow1217 1000.000000
R21217 MemRRow1217 MemRRow1267 1000.000000
R21267 MemRRow1267 MemRRow1318 1000.000000
R21318 MemRRow1318 MemRRow1370 1000.000000
R21370 MemRRow1370 MemRRow1423 1000.000000
R21423 MemRRow1423 MemRRow1477 1000.000000
R21477 MemRRow1477 MemRRow1532 1000.000000
R21532 MemRRow1532 MemRRow1588 1000.000000
R21588 MemRRow1588 MemRRow1645 1000.000000
R21645 MemRRow1645 MemRRow1703 1000.000000
R21703 MemRRow1703 MemRRow1762 1000.000000
R246 MemRRow46 MemRRow57 1000.000000
R257 MemRRow57 MemRRow69 1000.000000
R269 MemRRow69 MemRRow82 1000.000000
R282 MemRRow82 MemRRow96 1000.000000
R296 MemRRow96 MemRRow111 1000.000000
R2111 MemRRow111 MemRRow127 1000.000000
R2127 MemRRow127 MemRRow144 1000.000000
R2144 MemRRow144 MemRRow162 1000.000000
R2162 MemRRow162 MemRRow181 1000.000000
R2181 MemRRow181 MemRRow201 1000.000000
R2201 MemRRow201 MemRRow222 1000.000000
R2222 MemRRow222 MemRRow244 1000.000000
R2244 MemRRow244 MemRRow267 1000.000000
R2267 MemRRow267 MemRRow291 1000.000000
R2291 MemRRow291 MemRRow316 1000.000000
R2316 MemRRow316 MemRRow342 1000.000000
R2342 MemRRow342 MemRRow369 1000.000000
R2369 MemRRow369 MemRRow397 1000.000000
R2397 MemRRow397 MemRRow426 1000.000000
R2426 MemRRow426 MemRRow456 1000.000000
R2456 MemRRow456 MemRRow487 1000.000000
R2487 MemRRow487 MemRRow519 1000.000000
R2519 MemRRow519 MemRRow552 1000.000000
R2552 MemRRow552 MemRRow586 1000.000000
R2586 MemRRow586 MemRRow621 1000.000000
R2621 MemRRow621 MemRRow657 1000.000000
R2657 MemRRow657 MemRRow694 1000.000000
R2694 MemRRow694 MemRRow732 1000.000000
R2732 MemRRow732 MemRRow771 1000.000000
R2771 MemRRow771 MemRRow811 1000.000000
R2811 MemRRow811 MemRRow852 1000.000000
R2852 MemRRow852 MemRRow894 1000.000000
R2894 MemRRow894 MemRRow937 1000.000000
R2937 MemRRow937 MemRRow981 1000.000000
R2981 MemRRow981 MemRRow1026 1000.000000
R21026 MemRRow1026 MemRRow1072 1000.000000
R21072 MemRRow1072 MemRRow1119 1000.000000
R21119 MemRRow1119 MemRRow1167 1000.000000
R21167 MemRRow1167 MemRRow1216 1000.000000
R21216 MemRRow1216 MemRRow1266 1000.000000
R21266 MemRRow1266 MemRRow1317 1000.000000
R21317 MemRRow1317 MemRRow1369 1000.000000
R21369 MemRRow1369 MemRRow1422 1000.000000
R21422 MemRRow1422 MemRRow1476 1000.000000
R21476 MemRRow1476 MemRRow1531 1000.000000
R21531 MemRRow1531 MemRRow1587 1000.000000
R21587 MemRRow1587 MemRRow1644 1000.000000
R21644 MemRRow1644 MemRRow1702 1000.000000
R21702 MemRRow1702 MemRRow1761 1000.000000
R21761 MemRRow1761 MemRRow1821 1000.000000
R256 MemRRow56 MemRRow68 1000.000000
R268 MemRRow68 MemRRow81 1000.000000
R281 MemRRow81 MemRRow95 1000.000000
R295 MemRRow95 MemRRow110 1000.000000
R2110 MemRRow110 MemRRow126 1000.000000
R2126 MemRRow126 MemRRow143 1000.000000
R2143 MemRRow143 MemRRow161 1000.000000
R2161 MemRRow161 MemRRow180 1000.000000
R2180 MemRRow180 MemRRow200 1000.000000
R2200 MemRRow200 MemRRow221 1000.000000
R2221 MemRRow221 MemRRow243 1000.000000
R2243 MemRRow243 MemRRow266 1000.000000
R2266 MemRRow266 MemRRow290 1000.000000
R2290 MemRRow290 MemRRow315 1000.000000
R2315 MemRRow315 MemRRow341 1000.000000
R2341 MemRRow341 MemRRow368 1000.000000
R2368 MemRRow368 MemRRow396 1000.000000
R2396 MemRRow396 MemRRow425 1000.000000
R2425 MemRRow425 MemRRow455 1000.000000
R2455 MemRRow455 MemRRow486 1000.000000
R2486 MemRRow486 MemRRow518 1000.000000
R2518 MemRRow518 MemRRow551 1000.000000
R2551 MemRRow551 MemRRow585 1000.000000
R2585 MemRRow585 MemRRow620 1000.000000
R2620 MemRRow620 MemRRow656 1000.000000
R2656 MemRRow656 MemRRow693 1000.000000
R2693 MemRRow693 MemRRow731 1000.000000
R2731 MemRRow731 MemRRow770 1000.000000
R2770 MemRRow770 MemRRow810 1000.000000
R2810 MemRRow810 MemRRow851 1000.000000
R2851 MemRRow851 MemRRow893 1000.000000
R2893 MemRRow893 MemRRow936 1000.000000
R2936 MemRRow936 MemRRow980 1000.000000
R2980 MemRRow980 MemRRow1025 1000.000000
R21025 MemRRow1025 MemRRow1071 1000.000000
R21071 MemRRow1071 MemRRow1118 1000.000000
R21118 MemRRow1118 MemRRow1166 1000.000000
R21166 MemRRow1166 MemRRow1215 1000.000000
R21215 MemRRow1215 MemRRow1265 1000.000000
R21265 MemRRow1265 MemRRow1316 1000.000000
R21316 MemRRow1316 MemRRow1368 1000.000000
R21368 MemRRow1368 MemRRow1421 1000.000000
R21421 MemRRow1421 MemRRow1475 1000.000000
R21475 MemRRow1475 MemRRow1530 1000.000000
R21530 MemRRow1530 MemRRow1586 1000.000000
R21586 MemRRow1586 MemRRow1643 1000.000000
R21643 MemRRow1643 MemRRow1701 1000.000000
R21701 MemRRow1701 MemRRow1760 1000.000000
R21760 MemRRow1760 MemRRow1820 1000.000000
R21820 MemRRow1820 MemRRow1881 1000.000000
R267 MemRRow67 MemRRow80 1000.000000
R280 MemRRow80 MemRRow94 1000.000000
R294 MemRRow94 MemRRow109 1000.000000
R2109 MemRRow109 MemRRow125 1000.000000
R2125 MemRRow125 MemRRow142 1000.000000
R2142 MemRRow142 MemRRow160 1000.000000
R2160 MemRRow160 MemRRow179 1000.000000
R2179 MemRRow179 MemRRow199 1000.000000
R2199 MemRRow199 MemRRow220 1000.000000
R2220 MemRRow220 MemRRow242 1000.000000
R2242 MemRRow242 MemRRow265 1000.000000
R2265 MemRRow265 MemRRow289 1000.000000
R2289 MemRRow289 MemRRow314 1000.000000
R2314 MemRRow314 MemRRow340 1000.000000
R2340 MemRRow340 MemRRow367 1000.000000
R2367 MemRRow367 MemRRow395 1000.000000
R2395 MemRRow395 MemRRow424 1000.000000
R2424 MemRRow424 MemRRow454 1000.000000
R2454 MemRRow454 MemRRow485 1000.000000
R2485 MemRRow485 MemRRow517 1000.000000
R2517 MemRRow517 MemRRow550 1000.000000
R2550 MemRRow550 MemRRow584 1000.000000
R2584 MemRRow584 MemRRow619 1000.000000
R2619 MemRRow619 MemRRow655 1000.000000
R2655 MemRRow655 MemRRow692 1000.000000
R2692 MemRRow692 MemRRow730 1000.000000
R2730 MemRRow730 MemRRow769 1000.000000
R2769 MemRRow769 MemRRow809 1000.000000
R2809 MemRRow809 MemRRow850 1000.000000
R2850 MemRRow850 MemRRow892 1000.000000
R2892 MemRRow892 MemRRow935 1000.000000
R2935 MemRRow935 MemRRow979 1000.000000
R2979 MemRRow979 MemRRow1024 1000.000000
R21024 MemRRow1024 MemRRow1070 1000.000000
R21070 MemRRow1070 MemRRow1117 1000.000000
R21117 MemRRow1117 MemRRow1165 1000.000000
R21165 MemRRow1165 MemRRow1214 1000.000000
R21214 MemRRow1214 MemRRow1264 1000.000000
R21264 MemRRow1264 MemRRow1315 1000.000000
R21315 MemRRow1315 MemRRow1367 1000.000000
R21367 MemRRow1367 MemRRow1420 1000.000000
R21420 MemRRow1420 MemRRow1474 1000.000000
R21474 MemRRow1474 MemRRow1529 1000.000000
R21529 MemRRow1529 MemRRow1585 1000.000000
R21585 MemRRow1585 MemRRow1642 1000.000000
R21642 MemRRow1642 MemRRow1700 1000.000000
R21700 MemRRow1700 MemRRow1759 1000.000000
R21759 MemRRow1759 MemRRow1819 1000.000000
R21819 MemRRow1819 MemRRow1880 1000.000000
R21880 MemRRow1880 MemRRow1942 1000.000000
R279 MemRRow79 MemRRow93 1000.000000
R293 MemRRow93 MemRRow108 1000.000000
R2108 MemRRow108 MemRRow124 1000.000000
R2124 MemRRow124 MemRRow141 1000.000000
R2141 MemRRow141 MemRRow159 1000.000000
R2159 MemRRow159 MemRRow178 1000.000000
R2178 MemRRow178 MemRRow198 1000.000000
R2198 MemRRow198 MemRRow219 1000.000000
R2219 MemRRow219 MemRRow241 1000.000000
R2241 MemRRow241 MemRRow264 1000.000000
R2264 MemRRow264 MemRRow288 1000.000000
R2288 MemRRow288 MemRRow313 1000.000000
R2313 MemRRow313 MemRRow339 1000.000000
R2339 MemRRow339 MemRRow366 1000.000000
R2366 MemRRow366 MemRRow394 1000.000000
R2394 MemRRow394 MemRRow423 1000.000000
R2423 MemRRow423 MemRRow453 1000.000000
R2453 MemRRow453 MemRRow484 1000.000000
R2484 MemRRow484 MemRRow516 1000.000000
R2516 MemRRow516 MemRRow549 1000.000000
R2549 MemRRow549 MemRRow583 1000.000000
R2583 MemRRow583 MemRRow618 1000.000000
R2618 MemRRow618 MemRRow654 1000.000000
R2654 MemRRow654 MemRRow691 1000.000000
R2691 MemRRow691 MemRRow729 1000.000000
R2729 MemRRow729 MemRRow768 1000.000000
R2768 MemRRow768 MemRRow808 1000.000000
R2808 MemRRow808 MemRRow849 1000.000000
R2849 MemRRow849 MemRRow891 1000.000000
R2891 MemRRow891 MemRRow934 1000.000000
R2934 MemRRow934 MemRRow978 1000.000000
R2978 MemRRow978 MemRRow1023 1000.000000
R21023 MemRRow1023 MemRRow1069 1000.000000
R21069 MemRRow1069 MemRRow1116 1000.000000
R21116 MemRRow1116 MemRRow1164 1000.000000
R21164 MemRRow1164 MemRRow1213 1000.000000
R21213 MemRRow1213 MemRRow1263 1000.000000
R21263 MemRRow1263 MemRRow1314 1000.000000
R21314 MemRRow1314 MemRRow1366 1000.000000
R21366 MemRRow1366 MemRRow1419 1000.000000
R21419 MemRRow1419 MemRRow1473 1000.000000
R21473 MemRRow1473 MemRRow1528 1000.000000
R21528 MemRRow1528 MemRRow1584 1000.000000
R21584 MemRRow1584 MemRRow1641 1000.000000
R21641 MemRRow1641 MemRRow1699 1000.000000
R21699 MemRRow1699 MemRRow1758 1000.000000
R21758 MemRRow1758 MemRRow1818 1000.000000
R21818 MemRRow1818 MemRRow1879 1000.000000
R21879 MemRRow1879 MemRRow1941 1000.000000
R21941 MemRRow1941 MemRRow2004 1000.000000
R292 MemRRow92 MemRRow107 1000.000000
R2107 MemRRow107 MemRRow123 1000.000000
R2123 MemRRow123 MemRRow140 1000.000000
R2140 MemRRow140 MemRRow158 1000.000000
R2158 MemRRow158 MemRRow177 1000.000000
R2177 MemRRow177 MemRRow197 1000.000000
R2197 MemRRow197 MemRRow218 1000.000000
R2218 MemRRow218 MemRRow240 1000.000000
R2240 MemRRow240 MemRRow263 1000.000000
R2263 MemRRow263 MemRRow287 1000.000000
R2287 MemRRow287 MemRRow312 1000.000000
R2312 MemRRow312 MemRRow338 1000.000000
R2338 MemRRow338 MemRRow365 1000.000000
R2365 MemRRow365 MemRRow393 1000.000000
R2393 MemRRow393 MemRRow422 1000.000000
R2422 MemRRow422 MemRRow452 1000.000000
R2452 MemRRow452 MemRRow483 1000.000000
R2483 MemRRow483 MemRRow515 1000.000000
R2515 MemRRow515 MemRRow548 1000.000000
R2548 MemRRow548 MemRRow582 1000.000000
R2582 MemRRow582 MemRRow617 1000.000000
R2617 MemRRow617 MemRRow653 1000.000000
R2653 MemRRow653 MemRRow690 1000.000000
R2690 MemRRow690 MemRRow728 1000.000000
R2728 MemRRow728 MemRRow767 1000.000000
R2767 MemRRow767 MemRRow807 1000.000000
R2807 MemRRow807 MemRRow848 1000.000000
R2848 MemRRow848 MemRRow890 1000.000000
R2890 MemRRow890 MemRRow933 1000.000000
R2933 MemRRow933 MemRRow977 1000.000000
R2977 MemRRow977 MemRRow1022 1000.000000
R21022 MemRRow1022 MemRRow1068 1000.000000
R21068 MemRRow1068 MemRRow1115 1000.000000
R21115 MemRRow1115 MemRRow1163 1000.000000
R21163 MemRRow1163 MemRRow1212 1000.000000
R21212 MemRRow1212 MemRRow1262 1000.000000
R21262 MemRRow1262 MemRRow1313 1000.000000
R21313 MemRRow1313 MemRRow1365 1000.000000
R21365 MemRRow1365 MemRRow1418 1000.000000
R21418 MemRRow1418 MemRRow1472 1000.000000
R21472 MemRRow1472 MemRRow1527 1000.000000
R21527 MemRRow1527 MemRRow1583 1000.000000
R21583 MemRRow1583 MemRRow1640 1000.000000
R21640 MemRRow1640 MemRRow1698 1000.000000
R21698 MemRRow1698 MemRRow1757 1000.000000
R21757 MemRRow1757 MemRRow1817 1000.000000
R21817 MemRRow1817 MemRRow1878 1000.000000
R21878 MemRRow1878 MemRRow1940 1000.000000
R21940 MemRRow1940 MemRRow2003 1000.000000
R22003 MemRRow2003 MemRRow2067 1000.000000
R2106 MemRRow106 MemRRow122 1000.000000
R2122 MemRRow122 MemRRow139 1000.000000
R2139 MemRRow139 MemRRow157 1000.000000
R2157 MemRRow157 MemRRow176 1000.000000
R2176 MemRRow176 MemRRow196 1000.000000
R2196 MemRRow196 MemRRow217 1000.000000
R2217 MemRRow217 MemRRow239 1000.000000
R2239 MemRRow239 MemRRow262 1000.000000
R2262 MemRRow262 MemRRow286 1000.000000
R2286 MemRRow286 MemRRow311 1000.000000
R2311 MemRRow311 MemRRow337 1000.000000
R2337 MemRRow337 MemRRow364 1000.000000
R2364 MemRRow364 MemRRow392 1000.000000
R2392 MemRRow392 MemRRow421 1000.000000
R2421 MemRRow421 MemRRow451 1000.000000
R2451 MemRRow451 MemRRow482 1000.000000
R2482 MemRRow482 MemRRow514 1000.000000
R2514 MemRRow514 MemRRow547 1000.000000
R2547 MemRRow547 MemRRow581 1000.000000
R2581 MemRRow581 MemRRow616 1000.000000
R2616 MemRRow616 MemRRow652 1000.000000
R2652 MemRRow652 MemRRow689 1000.000000
R2689 MemRRow689 MemRRow727 1000.000000
R2727 MemRRow727 MemRRow766 1000.000000
R2766 MemRRow766 MemRRow806 1000.000000
R2806 MemRRow806 MemRRow847 1000.000000
R2847 MemRRow847 MemRRow889 1000.000000
R2889 MemRRow889 MemRRow932 1000.000000
R2932 MemRRow932 MemRRow976 1000.000000
R2976 MemRRow976 MemRRow1021 1000.000000
R21021 MemRRow1021 MemRRow1067 1000.000000
R21067 MemRRow1067 MemRRow1114 1000.000000
R21114 MemRRow1114 MemRRow1162 1000.000000
R21162 MemRRow1162 MemRRow1211 1000.000000
R21211 MemRRow1211 MemRRow1261 1000.000000
R21261 MemRRow1261 MemRRow1312 1000.000000
R21312 MemRRow1312 MemRRow1364 1000.000000
R21364 MemRRow1364 MemRRow1417 1000.000000
R21417 MemRRow1417 MemRRow1471 1000.000000
R21471 MemRRow1471 MemRRow1526 1000.000000
R21526 MemRRow1526 MemRRow1582 1000.000000
R21582 MemRRow1582 MemRRow1639 1000.000000
R21639 MemRRow1639 MemRRow1697 1000.000000
R21697 MemRRow1697 MemRRow1756 1000.000000
R21756 MemRRow1756 MemRRow1816 1000.000000
R21816 MemRRow1816 MemRRow1877 1000.000000
R21877 MemRRow1877 MemRRow1939 1000.000000
R21939 MemRRow1939 MemRRow2002 1000.000000
R22002 MemRRow2002 MemRRow2066 1000.000000
R22066 MemRRow2066 MemRRow2131 1000.000000
R2121 MemRRow121 MemRRow138 1000.000000
R2138 MemRRow138 MemRRow156 1000.000000
R2156 MemRRow156 MemRRow175 1000.000000
R2175 MemRRow175 MemRRow195 1000.000000
R2195 MemRRow195 MemRRow216 1000.000000
R2216 MemRRow216 MemRRow238 1000.000000
R2238 MemRRow238 MemRRow261 1000.000000
R2261 MemRRow261 MemRRow285 1000.000000
R2285 MemRRow285 MemRRow310 1000.000000
R2310 MemRRow310 MemRRow336 1000.000000
R2336 MemRRow336 MemRRow363 1000.000000
R2363 MemRRow363 MemRRow391 1000.000000
R2391 MemRRow391 MemRRow420 1000.000000
R2420 MemRRow420 MemRRow450 1000.000000
R2450 MemRRow450 MemRRow481 1000.000000
R2481 MemRRow481 MemRRow513 1000.000000
R2513 MemRRow513 MemRRow546 1000.000000
R2546 MemRRow546 MemRRow580 1000.000000
R2580 MemRRow580 MemRRow615 1000.000000
R2615 MemRRow615 MemRRow651 1000.000000
R2651 MemRRow651 MemRRow688 1000.000000
R2688 MemRRow688 MemRRow726 1000.000000
R2726 MemRRow726 MemRRow765 1000.000000
R2765 MemRRow765 MemRRow805 1000.000000
R2805 MemRRow805 MemRRow846 1000.000000
R2846 MemRRow846 MemRRow888 1000.000000
R2888 MemRRow888 MemRRow931 1000.000000
R2931 MemRRow931 MemRRow975 1000.000000
R2975 MemRRow975 MemRRow1020 1000.000000
R21020 MemRRow1020 MemRRow1066 1000.000000
R21066 MemRRow1066 MemRRow1113 1000.000000
R21113 MemRRow1113 MemRRow1161 1000.000000
R21161 MemRRow1161 MemRRow1210 1000.000000
R21210 MemRRow1210 MemRRow1260 1000.000000
R21260 MemRRow1260 MemRRow1311 1000.000000
R21311 MemRRow1311 MemRRow1363 1000.000000
R21363 MemRRow1363 MemRRow1416 1000.000000
R21416 MemRRow1416 MemRRow1470 1000.000000
R21470 MemRRow1470 MemRRow1525 1000.000000
R21525 MemRRow1525 MemRRow1581 1000.000000
R21581 MemRRow1581 MemRRow1638 1000.000000
R21638 MemRRow1638 MemRRow1696 1000.000000
R21696 MemRRow1696 MemRRow1755 1000.000000
R21755 MemRRow1755 MemRRow1815 1000.000000
R21815 MemRRow1815 MemRRow1876 1000.000000
R21876 MemRRow1876 MemRRow1938 1000.000000
R21938 MemRRow1938 MemRRow2001 1000.000000
R22001 MemRRow2001 MemRRow2065 1000.000000
R22065 MemRRow2065 MemRRow2130 1000.000000
R22130 MemRRow2130 MemRRow2196 1000.000000
R2137 MemRRow137 MemRRow155 1000.000000
R2155 MemRRow155 MemRRow174 1000.000000
R2174 MemRRow174 MemRRow194 1000.000000
R2194 MemRRow194 MemRRow215 1000.000000
R2215 MemRRow215 MemRRow237 1000.000000
R2237 MemRRow237 MemRRow260 1000.000000
R2260 MemRRow260 MemRRow284 1000.000000
R2284 MemRRow284 MemRRow309 1000.000000
R2309 MemRRow309 MemRRow335 1000.000000
R2335 MemRRow335 MemRRow362 1000.000000
R2362 MemRRow362 MemRRow390 1000.000000
R2390 MemRRow390 MemRRow419 1000.000000
R2419 MemRRow419 MemRRow449 1000.000000
R2449 MemRRow449 MemRRow480 1000.000000
R2480 MemRRow480 MemRRow512 1000.000000
R2512 MemRRow512 MemRRow545 1000.000000
R2545 MemRRow545 MemRRow579 1000.000000
R2579 MemRRow579 MemRRow614 1000.000000
R2614 MemRRow614 MemRRow650 1000.000000
R2650 MemRRow650 MemRRow687 1000.000000
R2687 MemRRow687 MemRRow725 1000.000000
R2725 MemRRow725 MemRRow764 1000.000000
R2764 MemRRow764 MemRRow804 1000.000000
R2804 MemRRow804 MemRRow845 1000.000000
R2845 MemRRow845 MemRRow887 1000.000000
R2887 MemRRow887 MemRRow930 1000.000000
R2930 MemRRow930 MemRRow974 1000.000000
R2974 MemRRow974 MemRRow1019 1000.000000
R21019 MemRRow1019 MemRRow1065 1000.000000
R21065 MemRRow1065 MemRRow1112 1000.000000
R21112 MemRRow1112 MemRRow1160 1000.000000
R21160 MemRRow1160 MemRRow1209 1000.000000
R21209 MemRRow1209 MemRRow1259 1000.000000
R21259 MemRRow1259 MemRRow1310 1000.000000
R21310 MemRRow1310 MemRRow1362 1000.000000
R21362 MemRRow1362 MemRRow1415 1000.000000
R21415 MemRRow1415 MemRRow1469 1000.000000
R21469 MemRRow1469 MemRRow1524 1000.000000
R21524 MemRRow1524 MemRRow1580 1000.000000
R21580 MemRRow1580 MemRRow1637 1000.000000
R21637 MemRRow1637 MemRRow1695 1000.000000
R21695 MemRRow1695 MemRRow1754 1000.000000
R21754 MemRRow1754 MemRRow1814 1000.000000
R21814 MemRRow1814 MemRRow1875 1000.000000
R21875 MemRRow1875 MemRRow1937 1000.000000
R21937 MemRRow1937 MemRRow2000 1000.000000
R22000 MemRRow2000 MemRRow2064 1000.000000
R22064 MemRRow2064 MemRRow2129 1000.000000
R22129 MemRRow2129 MemRRow2195 1000.000000
R22195 MemRRow2195 MemRRow2262 1000.000000
R2154 MemRRow154 MemRRow173 1000.000000
R2173 MemRRow173 MemRRow193 1000.000000
R2193 MemRRow193 MemRRow214 1000.000000
R2214 MemRRow214 MemRRow236 1000.000000
R2236 MemRRow236 MemRRow259 1000.000000
R2259 MemRRow259 MemRRow283 1000.000000
R2283 MemRRow283 MemRRow308 1000.000000
R2308 MemRRow308 MemRRow334 1000.000000
R2334 MemRRow334 MemRRow361 1000.000000
R2361 MemRRow361 MemRRow389 1000.000000
R2389 MemRRow389 MemRRow418 1000.000000
R2418 MemRRow418 MemRRow448 1000.000000
R2448 MemRRow448 MemRRow479 1000.000000
R2479 MemRRow479 MemRRow511 1000.000000
R2511 MemRRow511 MemRRow544 1000.000000
R2544 MemRRow544 MemRRow578 1000.000000
R2578 MemRRow578 MemRRow613 1000.000000
R2613 MemRRow613 MemRRow649 1000.000000
R2649 MemRRow649 MemRRow686 1000.000000
R2686 MemRRow686 MemRRow724 1000.000000
R2724 MemRRow724 MemRRow763 1000.000000
R2763 MemRRow763 MemRRow803 1000.000000
R2803 MemRRow803 MemRRow844 1000.000000
R2844 MemRRow844 MemRRow886 1000.000000
R2886 MemRRow886 MemRRow929 1000.000000
R2929 MemRRow929 MemRRow973 1000.000000
R2973 MemRRow973 MemRRow1018 1000.000000
R21018 MemRRow1018 MemRRow1064 1000.000000
R21064 MemRRow1064 MemRRow1111 1000.000000
R21111 MemRRow1111 MemRRow1159 1000.000000
R21159 MemRRow1159 MemRRow1208 1000.000000
R21208 MemRRow1208 MemRRow1258 1000.000000
R21258 MemRRow1258 MemRRow1309 1000.000000
R21309 MemRRow1309 MemRRow1361 1000.000000
R21361 MemRRow1361 MemRRow1414 1000.000000
R21414 MemRRow1414 MemRRow1468 1000.000000
R21468 MemRRow1468 MemRRow1523 1000.000000
R21523 MemRRow1523 MemRRow1579 1000.000000
R21579 MemRRow1579 MemRRow1636 1000.000000
R21636 MemRRow1636 MemRRow1694 1000.000000
R21694 MemRRow1694 MemRRow1753 1000.000000
R21753 MemRRow1753 MemRRow1813 1000.000000
R21813 MemRRow1813 MemRRow1874 1000.000000
R21874 MemRRow1874 MemRRow1936 1000.000000
R21936 MemRRow1936 MemRRow1999 1000.000000
R21999 MemRRow1999 MemRRow2063 1000.000000
R22063 MemRRow2063 MemRRow2128 1000.000000
R22128 MemRRow2128 MemRRow2194 1000.000000
R22194 MemRRow2194 MemRRow2261 1000.000000
R22261 MemRRow2261 MemRRow2329 1000.000000
R2172 MemRRow172 MemRRow192 1000.000000
R2192 MemRRow192 MemRRow213 1000.000000
R2213 MemRRow213 MemRRow235 1000.000000
R2235 MemRRow235 MemRRow258 1000.000000
R2258 MemRRow258 MemRRow282 1000.000000
R2282 MemRRow282 MemRRow307 1000.000000
R2307 MemRRow307 MemRRow333 1000.000000
R2333 MemRRow333 MemRRow360 1000.000000
R2360 MemRRow360 MemRRow388 1000.000000
R2388 MemRRow388 MemRRow417 1000.000000
R2417 MemRRow417 MemRRow447 1000.000000
R2447 MemRRow447 MemRRow478 1000.000000
R2478 MemRRow478 MemRRow510 1000.000000
R2510 MemRRow510 MemRRow543 1000.000000
R2543 MemRRow543 MemRRow577 1000.000000
R2577 MemRRow577 MemRRow612 1000.000000
R2612 MemRRow612 MemRRow648 1000.000000
R2648 MemRRow648 MemRRow685 1000.000000
R2685 MemRRow685 MemRRow723 1000.000000
R2723 MemRRow723 MemRRow762 1000.000000
R2762 MemRRow762 MemRRow802 1000.000000
R2802 MemRRow802 MemRRow843 1000.000000
R2843 MemRRow843 MemRRow885 1000.000000
R2885 MemRRow885 MemRRow928 1000.000000
R2928 MemRRow928 MemRRow972 1000.000000
R2972 MemRRow972 MemRRow1017 1000.000000
R21017 MemRRow1017 MemRRow1063 1000.000000
R21063 MemRRow1063 MemRRow1110 1000.000000
R21110 MemRRow1110 MemRRow1158 1000.000000
R21158 MemRRow1158 MemRRow1207 1000.000000
R21207 MemRRow1207 MemRRow1257 1000.000000
R21257 MemRRow1257 MemRRow1308 1000.000000
R21308 MemRRow1308 MemRRow1360 1000.000000
R21360 MemRRow1360 MemRRow1413 1000.000000
R21413 MemRRow1413 MemRRow1467 1000.000000
R21467 MemRRow1467 MemRRow1522 1000.000000
R21522 MemRRow1522 MemRRow1578 1000.000000
R21578 MemRRow1578 MemRRow1635 1000.000000
R21635 MemRRow1635 MemRRow1693 1000.000000
R21693 MemRRow1693 MemRRow1752 1000.000000
R21752 MemRRow1752 MemRRow1812 1000.000000
R21812 MemRRow1812 MemRRow1873 1000.000000
R21873 MemRRow1873 MemRRow1935 1000.000000
R21935 MemRRow1935 MemRRow1998 1000.000000
R21998 MemRRow1998 MemRRow2062 1000.000000
R22062 MemRRow2062 MemRRow2127 1000.000000
R22127 MemRRow2127 MemRRow2193 1000.000000
R22193 MemRRow2193 MemRRow2260 1000.000000
R22260 MemRRow2260 MemRRow2328 1000.000000
R22328 MemRRow2328 MemRRow2397 1000.000000
R2191 MemRRow191 MemRRow212 1000.000000
R2212 MemRRow212 MemRRow234 1000.000000
R2234 MemRRow234 MemRRow257 1000.000000
R2257 MemRRow257 MemRRow281 1000.000000
R2281 MemRRow281 MemRRow306 1000.000000
R2306 MemRRow306 MemRRow332 1000.000000
R2332 MemRRow332 MemRRow359 1000.000000
R2359 MemRRow359 MemRRow387 1000.000000
R2387 MemRRow387 MemRRow416 1000.000000
R2416 MemRRow416 MemRRow446 1000.000000
R2446 MemRRow446 MemRRow477 1000.000000
R2477 MemRRow477 MemRRow509 1000.000000
R2509 MemRRow509 MemRRow542 1000.000000
R2542 MemRRow542 MemRRow576 1000.000000
R2576 MemRRow576 MemRRow611 1000.000000
R2611 MemRRow611 MemRRow647 1000.000000
R2647 MemRRow647 MemRRow684 1000.000000
R2684 MemRRow684 MemRRow722 1000.000000
R2722 MemRRow722 MemRRow761 1000.000000
R2761 MemRRow761 MemRRow801 1000.000000
R2801 MemRRow801 MemRRow842 1000.000000
R2842 MemRRow842 MemRRow884 1000.000000
R2884 MemRRow884 MemRRow927 1000.000000
R2927 MemRRow927 MemRRow971 1000.000000
R2971 MemRRow971 MemRRow1016 1000.000000
R21016 MemRRow1016 MemRRow1062 1000.000000
R21062 MemRRow1062 MemRRow1109 1000.000000
R21109 MemRRow1109 MemRRow1157 1000.000000
R21157 MemRRow1157 MemRRow1206 1000.000000
R21206 MemRRow1206 MemRRow1256 1000.000000
R21256 MemRRow1256 MemRRow1307 1000.000000
R21307 MemRRow1307 MemRRow1359 1000.000000
R21359 MemRRow1359 MemRRow1412 1000.000000
R21412 MemRRow1412 MemRRow1466 1000.000000
R21466 MemRRow1466 MemRRow1521 1000.000000
R21521 MemRRow1521 MemRRow1577 1000.000000
R21577 MemRRow1577 MemRRow1634 1000.000000
R21634 MemRRow1634 MemRRow1692 1000.000000
R21692 MemRRow1692 MemRRow1751 1000.000000
R21751 MemRRow1751 MemRRow1811 1000.000000
R21811 MemRRow1811 MemRRow1872 1000.000000
R21872 MemRRow1872 MemRRow1934 1000.000000
R21934 MemRRow1934 MemRRow1997 1000.000000
R21997 MemRRow1997 MemRRow2061 1000.000000
R22061 MemRRow2061 MemRRow2126 1000.000000
R22126 MemRRow2126 MemRRow2192 1000.000000
R22192 MemRRow2192 MemRRow2259 1000.000000
R22259 MemRRow2259 MemRRow2327 1000.000000
R22327 MemRRow2327 MemRRow2396 1000.000000
R22396 MemRRow2396 MemRRow2466 1000.000000
R2211 MemRRow211 MemRRow233 1000.000000
R2233 MemRRow233 MemRRow256 1000.000000
R2256 MemRRow256 MemRRow280 1000.000000
R2280 MemRRow280 MemRRow305 1000.000000
R2305 MemRRow305 MemRRow331 1000.000000
R2331 MemRRow331 MemRRow358 1000.000000
R2358 MemRRow358 MemRRow386 1000.000000
R2386 MemRRow386 MemRRow415 1000.000000
R2415 MemRRow415 MemRRow445 1000.000000
R2445 MemRRow445 MemRRow476 1000.000000
R2476 MemRRow476 MemRRow508 1000.000000
R2508 MemRRow508 MemRRow541 1000.000000
R2541 MemRRow541 MemRRow575 1000.000000
R2575 MemRRow575 MemRRow610 1000.000000
R2610 MemRRow610 MemRRow646 1000.000000
R2646 MemRRow646 MemRRow683 1000.000000
R2683 MemRRow683 MemRRow721 1000.000000
R2721 MemRRow721 MemRRow760 1000.000000
R2760 MemRRow760 MemRRow800 1000.000000
R2800 MemRRow800 MemRRow841 1000.000000
R2841 MemRRow841 MemRRow883 1000.000000
R2883 MemRRow883 MemRRow926 1000.000000
R2926 MemRRow926 MemRRow970 1000.000000
R2970 MemRRow970 MemRRow1015 1000.000000
R21015 MemRRow1015 MemRRow1061 1000.000000
R21061 MemRRow1061 MemRRow1108 1000.000000
R21108 MemRRow1108 MemRRow1156 1000.000000
R21156 MemRRow1156 MemRRow1205 1000.000000
R21205 MemRRow1205 MemRRow1255 1000.000000
R21255 MemRRow1255 MemRRow1306 1000.000000
R21306 MemRRow1306 MemRRow1358 1000.000000
R21358 MemRRow1358 MemRRow1411 1000.000000
R21411 MemRRow1411 MemRRow1465 1000.000000
R21465 MemRRow1465 MemRRow1520 1000.000000
R21520 MemRRow1520 MemRRow1576 1000.000000
R21576 MemRRow1576 MemRRow1633 1000.000000
R21633 MemRRow1633 MemRRow1691 1000.000000
R21691 MemRRow1691 MemRRow1750 1000.000000
R21750 MemRRow1750 MemRRow1810 1000.000000
R21810 MemRRow1810 MemRRow1871 1000.000000
R21871 MemRRow1871 MemRRow1933 1000.000000
R21933 MemRRow1933 MemRRow1996 1000.000000
R21996 MemRRow1996 MemRRow2060 1000.000000
R22060 MemRRow2060 MemRRow2125 1000.000000
R22125 MemRRow2125 MemRRow2191 1000.000000
R22191 MemRRow2191 MemRRow2258 1000.000000
R22258 MemRRow2258 MemRRow2326 1000.000000
R22326 MemRRow2326 MemRRow2395 1000.000000
R22395 MemRRow2395 MemRRow2465 1000.000000
R22465 MemRRow2465 MemRRow2536 1000.000000
R2232 MemRRow232 MemRRow255 1000.000000
R2255 MemRRow255 MemRRow279 1000.000000
R2279 MemRRow279 MemRRow304 1000.000000
R2304 MemRRow304 MemRRow330 1000.000000
R2330 MemRRow330 MemRRow357 1000.000000
R2357 MemRRow357 MemRRow385 1000.000000
R2385 MemRRow385 MemRRow414 1000.000000
R2414 MemRRow414 MemRRow444 1000.000000
R2444 MemRRow444 MemRRow475 1000.000000
R2475 MemRRow475 MemRRow507 1000.000000
R2507 MemRRow507 MemRRow540 1000.000000
R2540 MemRRow540 MemRRow574 1000.000000
R2574 MemRRow574 MemRRow609 1000.000000
R2609 MemRRow609 MemRRow645 1000.000000
R2645 MemRRow645 MemRRow682 1000.000000
R2682 MemRRow682 MemRRow720 1000.000000
R2720 MemRRow720 MemRRow759 1000.000000
R2759 MemRRow759 MemRRow799 1000.000000
R2799 MemRRow799 MemRRow840 1000.000000
R2840 MemRRow840 MemRRow882 1000.000000
R2882 MemRRow882 MemRRow925 1000.000000
R2925 MemRRow925 MemRRow969 1000.000000
R2969 MemRRow969 MemRRow1014 1000.000000
R21014 MemRRow1014 MemRRow1060 1000.000000
R21060 MemRRow1060 MemRRow1107 1000.000000
R21107 MemRRow1107 MemRRow1155 1000.000000
R21155 MemRRow1155 MemRRow1204 1000.000000
R21204 MemRRow1204 MemRRow1254 1000.000000
R21254 MemRRow1254 MemRRow1305 1000.000000
R21305 MemRRow1305 MemRRow1357 1000.000000
R21357 MemRRow1357 MemRRow1410 1000.000000
R21410 MemRRow1410 MemRRow1464 1000.000000
R21464 MemRRow1464 MemRRow1519 1000.000000
R21519 MemRRow1519 MemRRow1575 1000.000000
R21575 MemRRow1575 MemRRow1632 1000.000000
R21632 MemRRow1632 MemRRow1690 1000.000000
R21690 MemRRow1690 MemRRow1749 1000.000000
R21749 MemRRow1749 MemRRow1809 1000.000000
R21809 MemRRow1809 MemRRow1870 1000.000000
R21870 MemRRow1870 MemRRow1932 1000.000000
R21932 MemRRow1932 MemRRow1995 1000.000000
R21995 MemRRow1995 MemRRow2059 1000.000000
R22059 MemRRow2059 MemRRow2124 1000.000000
R22124 MemRRow2124 MemRRow2190 1000.000000
R22190 MemRRow2190 MemRRow2257 1000.000000
R22257 MemRRow2257 MemRRow2325 1000.000000
R22325 MemRRow2325 MemRRow2394 1000.000000
R22394 MemRRow2394 MemRRow2464 1000.000000
R22464 MemRRow2464 MemRRow2535 1000.000000
R22535 MemRRow2535 MemRRow2607 1000.000000
R2254 MemRRow254 MemRRow278 1000.000000
R2278 MemRRow278 MemRRow303 1000.000000
R2303 MemRRow303 MemRRow329 1000.000000
R2329 MemRRow329 MemRRow356 1000.000000
R2356 MemRRow356 MemRRow384 1000.000000
R2384 MemRRow384 MemRRow413 1000.000000
R2413 MemRRow413 MemRRow443 1000.000000
R2443 MemRRow443 MemRRow474 1000.000000
R2474 MemRRow474 MemRRow506 1000.000000
R2506 MemRRow506 MemRRow539 1000.000000
R2539 MemRRow539 MemRRow573 1000.000000
R2573 MemRRow573 MemRRow608 1000.000000
R2608 MemRRow608 MemRRow644 1000.000000
R2644 MemRRow644 MemRRow681 1000.000000
R2681 MemRRow681 MemRRow719 1000.000000
R2719 MemRRow719 MemRRow758 1000.000000
R2758 MemRRow758 MemRRow798 1000.000000
R2798 MemRRow798 MemRRow839 1000.000000
R2839 MemRRow839 MemRRow881 1000.000000
R2881 MemRRow881 MemRRow924 1000.000000
R2924 MemRRow924 MemRRow968 1000.000000
R2968 MemRRow968 MemRRow1013 1000.000000
R21013 MemRRow1013 MemRRow1059 1000.000000
R21059 MemRRow1059 MemRRow1106 1000.000000
R21106 MemRRow1106 MemRRow1154 1000.000000
R21154 MemRRow1154 MemRRow1203 1000.000000
R21203 MemRRow1203 MemRRow1253 1000.000000
R21253 MemRRow1253 MemRRow1304 1000.000000
R21304 MemRRow1304 MemRRow1356 1000.000000
R21356 MemRRow1356 MemRRow1409 1000.000000
R21409 MemRRow1409 MemRRow1463 1000.000000
R21463 MemRRow1463 MemRRow1518 1000.000000
R21518 MemRRow1518 MemRRow1574 1000.000000
R21574 MemRRow1574 MemRRow1631 1000.000000
R21631 MemRRow1631 MemRRow1689 1000.000000
R21689 MemRRow1689 MemRRow1748 1000.000000
R21748 MemRRow1748 MemRRow1808 1000.000000
R21808 MemRRow1808 MemRRow1869 1000.000000
R21869 MemRRow1869 MemRRow1931 1000.000000
R21931 MemRRow1931 MemRRow1994 1000.000000
R21994 MemRRow1994 MemRRow2058 1000.000000
R22058 MemRRow2058 MemRRow2123 1000.000000
R22123 MemRRow2123 MemRRow2189 1000.000000
R22189 MemRRow2189 MemRRow2256 1000.000000
R22256 MemRRow2256 MemRRow2324 1000.000000
R22324 MemRRow2324 MemRRow2393 1000.000000
R22393 MemRRow2393 MemRRow2463 1000.000000
R22463 MemRRow2463 MemRRow2534 1000.000000
R22534 MemRRow2534 MemRRow2606 1000.000000
R22606 MemRRow2606 MemRRow2679 1000.000000
R2277 MemRRow277 MemRRow302 1000.000000
R2302 MemRRow302 MemRRow328 1000.000000
R2328 MemRRow328 MemRRow355 1000.000000
R2355 MemRRow355 MemRRow383 1000.000000
R2383 MemRRow383 MemRRow412 1000.000000
R2412 MemRRow412 MemRRow442 1000.000000
R2442 MemRRow442 MemRRow473 1000.000000
R2473 MemRRow473 MemRRow505 1000.000000
R2505 MemRRow505 MemRRow538 1000.000000
R2538 MemRRow538 MemRRow572 1000.000000
R2572 MemRRow572 MemRRow607 1000.000000
R2607 MemRRow607 MemRRow643 1000.000000
R2643 MemRRow643 MemRRow680 1000.000000
R2680 MemRRow680 MemRRow718 1000.000000
R2718 MemRRow718 MemRRow757 1000.000000
R2757 MemRRow757 MemRRow797 1000.000000
R2797 MemRRow797 MemRRow838 1000.000000
R2838 MemRRow838 MemRRow880 1000.000000
R2880 MemRRow880 MemRRow923 1000.000000
R2923 MemRRow923 MemRRow967 1000.000000
R2967 MemRRow967 MemRRow1012 1000.000000
R21012 MemRRow1012 MemRRow1058 1000.000000
R21058 MemRRow1058 MemRRow1105 1000.000000
R21105 MemRRow1105 MemRRow1153 1000.000000
R21153 MemRRow1153 MemRRow1202 1000.000000
R21202 MemRRow1202 MemRRow1252 1000.000000
R21252 MemRRow1252 MemRRow1303 1000.000000
R21303 MemRRow1303 MemRRow1355 1000.000000
R21355 MemRRow1355 MemRRow1408 1000.000000
R21408 MemRRow1408 MemRRow1462 1000.000000
R21462 MemRRow1462 MemRRow1517 1000.000000
R21517 MemRRow1517 MemRRow1573 1000.000000
R21573 MemRRow1573 MemRRow1630 1000.000000
R21630 MemRRow1630 MemRRow1688 1000.000000
R21688 MemRRow1688 MemRRow1747 1000.000000
R21747 MemRRow1747 MemRRow1807 1000.000000
R21807 MemRRow1807 MemRRow1868 1000.000000
R21868 MemRRow1868 MemRRow1930 1000.000000
R21930 MemRRow1930 MemRRow1993 1000.000000
R21993 MemRRow1993 MemRRow2057 1000.000000
R22057 MemRRow2057 MemRRow2122 1000.000000
R22122 MemRRow2122 MemRRow2188 1000.000000
R22188 MemRRow2188 MemRRow2255 1000.000000
R22255 MemRRow2255 MemRRow2323 1000.000000
R22323 MemRRow2323 MemRRow2392 1000.000000
R22392 MemRRow2392 MemRRow2462 1000.000000
R22462 MemRRow2462 MemRRow2533 1000.000000
R22533 MemRRow2533 MemRRow2605 1000.000000
R22605 MemRRow2605 MemRRow2678 1000.000000
R22678 MemRRow2678 MemRRow2752 1000.000000
R2301 MemRRow301 MemRRow327 1000.000000
R2327 MemRRow327 MemRRow354 1000.000000
R2354 MemRRow354 MemRRow382 1000.000000
R2382 MemRRow382 MemRRow411 1000.000000
R2411 MemRRow411 MemRRow441 1000.000000
R2441 MemRRow441 MemRRow472 1000.000000
R2472 MemRRow472 MemRRow504 1000.000000
R2504 MemRRow504 MemRRow537 1000.000000
R2537 MemRRow537 MemRRow571 1000.000000
R2571 MemRRow571 MemRRow606 1000.000000
R2606 MemRRow606 MemRRow642 1000.000000
R2642 MemRRow642 MemRRow679 1000.000000
R2679 MemRRow679 MemRRow717 1000.000000
R2717 MemRRow717 MemRRow756 1000.000000
R2756 MemRRow756 MemRRow796 1000.000000
R2796 MemRRow796 MemRRow837 1000.000000
R2837 MemRRow837 MemRRow879 1000.000000
R2879 MemRRow879 MemRRow922 1000.000000
R2922 MemRRow922 MemRRow966 1000.000000
R2966 MemRRow966 MemRRow1011 1000.000000
R21011 MemRRow1011 MemRRow1057 1000.000000
R21057 MemRRow1057 MemRRow1104 1000.000000
R21104 MemRRow1104 MemRRow1152 1000.000000
R21152 MemRRow1152 MemRRow1201 1000.000000
R21201 MemRRow1201 MemRRow1251 1000.000000
R21251 MemRRow1251 MemRRow1302 1000.000000
R21302 MemRRow1302 MemRRow1354 1000.000000
R21354 MemRRow1354 MemRRow1407 1000.000000
R21407 MemRRow1407 MemRRow1461 1000.000000
R21461 MemRRow1461 MemRRow1516 1000.000000
R21516 MemRRow1516 MemRRow1572 1000.000000
R21572 MemRRow1572 MemRRow1629 1000.000000
R21629 MemRRow1629 MemRRow1687 1000.000000
R21687 MemRRow1687 MemRRow1746 1000.000000
R21746 MemRRow1746 MemRRow1806 1000.000000
R21806 MemRRow1806 MemRRow1867 1000.000000
R21867 MemRRow1867 MemRRow1929 1000.000000
R21929 MemRRow1929 MemRRow1992 1000.000000
R21992 MemRRow1992 MemRRow2056 1000.000000
R22056 MemRRow2056 MemRRow2121 1000.000000
R22121 MemRRow2121 MemRRow2187 1000.000000
R22187 MemRRow2187 MemRRow2254 1000.000000
R22254 MemRRow2254 MemRRow2322 1000.000000
R22322 MemRRow2322 MemRRow2391 1000.000000
R22391 MemRRow2391 MemRRow2461 1000.000000
R22461 MemRRow2461 MemRRow2532 1000.000000
R22532 MemRRow2532 MemRRow2604 1000.000000
R22604 MemRRow2604 MemRRow2677 1000.000000
R22677 MemRRow2677 MemRRow2751 1000.000000
R22751 MemRRow2751 MemRRow2826 1000.000000
R2326 MemRRow326 MemRRow353 1000.000000
R2353 MemRRow353 MemRRow381 1000.000000
R2381 MemRRow381 MemRRow410 1000.000000
R2410 MemRRow410 MemRRow440 1000.000000
R2440 MemRRow440 MemRRow471 1000.000000
R2471 MemRRow471 MemRRow503 1000.000000
R2503 MemRRow503 MemRRow536 1000.000000
R2536 MemRRow536 MemRRow570 1000.000000
R2570 MemRRow570 MemRRow605 1000.000000
R2605 MemRRow605 MemRRow641 1000.000000
R2641 MemRRow641 MemRRow678 1000.000000
R2678 MemRRow678 MemRRow716 1000.000000
R2716 MemRRow716 MemRRow755 1000.000000
R2755 MemRRow755 MemRRow795 1000.000000
R2795 MemRRow795 MemRRow836 1000.000000
R2836 MemRRow836 MemRRow878 1000.000000
R2878 MemRRow878 MemRRow921 1000.000000
R2921 MemRRow921 MemRRow965 1000.000000
R2965 MemRRow965 MemRRow1010 1000.000000
R21010 MemRRow1010 MemRRow1056 1000.000000
R21056 MemRRow1056 MemRRow1103 1000.000000
R21103 MemRRow1103 MemRRow1151 1000.000000
R21151 MemRRow1151 MemRRow1200 1000.000000
R21200 MemRRow1200 MemRRow1250 1000.000000
R21250 MemRRow1250 MemRRow1301 1000.000000
R21301 MemRRow1301 MemRRow1353 1000.000000
R21353 MemRRow1353 MemRRow1406 1000.000000
R21406 MemRRow1406 MemRRow1460 1000.000000
R21460 MemRRow1460 MemRRow1515 1000.000000
R21515 MemRRow1515 MemRRow1571 1000.000000
R21571 MemRRow1571 MemRRow1628 1000.000000
R21628 MemRRow1628 MemRRow1686 1000.000000
R21686 MemRRow1686 MemRRow1745 1000.000000
R21745 MemRRow1745 MemRRow1805 1000.000000
R21805 MemRRow1805 MemRRow1866 1000.000000
R21866 MemRRow1866 MemRRow1928 1000.000000
R21928 MemRRow1928 MemRRow1991 1000.000000
R21991 MemRRow1991 MemRRow2055 1000.000000
R22055 MemRRow2055 MemRRow2120 1000.000000
R22120 MemRRow2120 MemRRow2186 1000.000000
R22186 MemRRow2186 MemRRow2253 1000.000000
R22253 MemRRow2253 MemRRow2321 1000.000000
R22321 MemRRow2321 MemRRow2390 1000.000000
R22390 MemRRow2390 MemRRow2460 1000.000000
R22460 MemRRow2460 MemRRow2531 1000.000000
R22531 MemRRow2531 MemRRow2603 1000.000000
R22603 MemRRow2603 MemRRow2676 1000.000000
R22676 MemRRow2676 MemRRow2750 1000.000000
R22750 MemRRow2750 MemRRow2825 1000.000000
R22825 MemRRow2825 MemRRow2901 1000.000000
R2352 MemRRow352 MemRRow380 1000.000000
R2380 MemRRow380 MemRRow409 1000.000000
R2409 MemRRow409 MemRRow439 1000.000000
R2439 MemRRow439 MemRRow470 1000.000000
R2470 MemRRow470 MemRRow502 1000.000000
R2502 MemRRow502 MemRRow535 1000.000000
R2535 MemRRow535 MemRRow569 1000.000000
R2569 MemRRow569 MemRRow604 1000.000000
R2604 MemRRow604 MemRRow640 1000.000000
R2640 MemRRow640 MemRRow677 1000.000000
R2677 MemRRow677 MemRRow715 1000.000000
R2715 MemRRow715 MemRRow754 1000.000000
R2754 MemRRow754 MemRRow794 1000.000000
R2794 MemRRow794 MemRRow835 1000.000000
R2835 MemRRow835 MemRRow877 1000.000000
R2877 MemRRow877 MemRRow920 1000.000000
R2920 MemRRow920 MemRRow964 1000.000000
R2964 MemRRow964 MemRRow1009 1000.000000
R21009 MemRRow1009 MemRRow1055 1000.000000
R21055 MemRRow1055 MemRRow1102 1000.000000
R21102 MemRRow1102 MemRRow1150 1000.000000
R21150 MemRRow1150 MemRRow1199 1000.000000
R21199 MemRRow1199 MemRRow1249 1000.000000
R21249 MemRRow1249 MemRRow1300 1000.000000
R21300 MemRRow1300 MemRRow1352 1000.000000
R21352 MemRRow1352 MemRRow1405 1000.000000
R21405 MemRRow1405 MemRRow1459 1000.000000
R21459 MemRRow1459 MemRRow1514 1000.000000
R21514 MemRRow1514 MemRRow1570 1000.000000
R21570 MemRRow1570 MemRRow1627 1000.000000
R21627 MemRRow1627 MemRRow1685 1000.000000
R21685 MemRRow1685 MemRRow1744 1000.000000
R21744 MemRRow1744 MemRRow1804 1000.000000
R21804 MemRRow1804 MemRRow1865 1000.000000
R21865 MemRRow1865 MemRRow1927 1000.000000
R21927 MemRRow1927 MemRRow1990 1000.000000
R21990 MemRRow1990 MemRRow2054 1000.000000
R22054 MemRRow2054 MemRRow2119 1000.000000
R22119 MemRRow2119 MemRRow2185 1000.000000
R22185 MemRRow2185 MemRRow2252 1000.000000
R22252 MemRRow2252 MemRRow2320 1000.000000
R22320 MemRRow2320 MemRRow2389 1000.000000
R22389 MemRRow2389 MemRRow2459 1000.000000
R22459 MemRRow2459 MemRRow2530 1000.000000
R22530 MemRRow2530 MemRRow2602 1000.000000
R22602 MemRRow2602 MemRRow2675 1000.000000
R22675 MemRRow2675 MemRRow2749 1000.000000
R22749 MemRRow2749 MemRRow2824 1000.000000
R22824 MemRRow2824 MemRRow2900 1000.000000
R22900 MemRRow2900 MemRRow2977 1000.000000
R2379 MemRRow379 MemRRow408 1000.000000
R2408 MemRRow408 MemRRow438 1000.000000
R2438 MemRRow438 MemRRow469 1000.000000
R2469 MemRRow469 MemRRow501 1000.000000
R2501 MemRRow501 MemRRow534 1000.000000
R2534 MemRRow534 MemRRow568 1000.000000
R2568 MemRRow568 MemRRow603 1000.000000
R2603 MemRRow603 MemRRow639 1000.000000
R2639 MemRRow639 MemRRow676 1000.000000
R2676 MemRRow676 MemRRow714 1000.000000
R2714 MemRRow714 MemRRow753 1000.000000
R2753 MemRRow753 MemRRow793 1000.000000
R2793 MemRRow793 MemRRow834 1000.000000
R2834 MemRRow834 MemRRow876 1000.000000
R2876 MemRRow876 MemRRow919 1000.000000
R2919 MemRRow919 MemRRow963 1000.000000
R2963 MemRRow963 MemRRow1008 1000.000000
R21008 MemRRow1008 MemRRow1054 1000.000000
R21054 MemRRow1054 MemRRow1101 1000.000000
R21101 MemRRow1101 MemRRow1149 1000.000000
R21149 MemRRow1149 MemRRow1198 1000.000000
R21198 MemRRow1198 MemRRow1248 1000.000000
R21248 MemRRow1248 MemRRow1299 1000.000000
R21299 MemRRow1299 MemRRow1351 1000.000000
R21351 MemRRow1351 MemRRow1404 1000.000000
R21404 MemRRow1404 MemRRow1458 1000.000000
R21458 MemRRow1458 MemRRow1513 1000.000000
R21513 MemRRow1513 MemRRow1569 1000.000000
R21569 MemRRow1569 MemRRow1626 1000.000000
R21626 MemRRow1626 MemRRow1684 1000.000000
R21684 MemRRow1684 MemRRow1743 1000.000000
R21743 MemRRow1743 MemRRow1803 1000.000000
R21803 MemRRow1803 MemRRow1864 1000.000000
R21864 MemRRow1864 MemRRow1926 1000.000000
R21926 MemRRow1926 MemRRow1989 1000.000000
R21989 MemRRow1989 MemRRow2053 1000.000000
R22053 MemRRow2053 MemRRow2118 1000.000000
R22118 MemRRow2118 MemRRow2184 1000.000000
R22184 MemRRow2184 MemRRow2251 1000.000000
R22251 MemRRow2251 MemRRow2319 1000.000000
R22319 MemRRow2319 MemRRow2388 1000.000000
R22388 MemRRow2388 MemRRow2458 1000.000000
R22458 MemRRow2458 MemRRow2529 1000.000000
R22529 MemRRow2529 MemRRow2601 1000.000000
R22601 MemRRow2601 MemRRow2674 1000.000000
R22674 MemRRow2674 MemRRow2748 1000.000000
R22748 MemRRow2748 MemRRow2823 1000.000000
R22823 MemRRow2823 MemRRow2899 1000.000000
R22899 MemRRow2899 MemRRow2976 1000.000000
R22976 MemRRow2976 MemRRow3054 1000.000000
R2407 MemRRow407 MemRRow437 1000.000000
R2437 MemRRow437 MemRRow468 1000.000000
R2468 MemRRow468 MemRRow500 1000.000000
R2500 MemRRow500 MemRRow533 1000.000000
R2533 MemRRow533 MemRRow567 1000.000000
R2567 MemRRow567 MemRRow602 1000.000000
R2602 MemRRow602 MemRRow638 1000.000000
R2638 MemRRow638 MemRRow675 1000.000000
R2675 MemRRow675 MemRRow713 1000.000000
R2713 MemRRow713 MemRRow752 1000.000000
R2752 MemRRow752 MemRRow792 1000.000000
R2792 MemRRow792 MemRRow833 1000.000000
R2833 MemRRow833 MemRRow875 1000.000000
R2875 MemRRow875 MemRRow918 1000.000000
R2918 MemRRow918 MemRRow962 1000.000000
R2962 MemRRow962 MemRRow1007 1000.000000
R21007 MemRRow1007 MemRRow1053 1000.000000
R21053 MemRRow1053 MemRRow1100 1000.000000
R21100 MemRRow1100 MemRRow1148 1000.000000
R21148 MemRRow1148 MemRRow1197 1000.000000
R21197 MemRRow1197 MemRRow1247 1000.000000
R21247 MemRRow1247 MemRRow1298 1000.000000
R21298 MemRRow1298 MemRRow1350 1000.000000
R21350 MemRRow1350 MemRRow1403 1000.000000
R21403 MemRRow1403 MemRRow1457 1000.000000
R21457 MemRRow1457 MemRRow1512 1000.000000
R21512 MemRRow1512 MemRRow1568 1000.000000
R21568 MemRRow1568 MemRRow1625 1000.000000
R21625 MemRRow1625 MemRRow1683 1000.000000
R21683 MemRRow1683 MemRRow1742 1000.000000
R21742 MemRRow1742 MemRRow1802 1000.000000
R21802 MemRRow1802 MemRRow1863 1000.000000
R21863 MemRRow1863 MemRRow1925 1000.000000
R21925 MemRRow1925 MemRRow1988 1000.000000
R21988 MemRRow1988 MemRRow2052 1000.000000
R22052 MemRRow2052 MemRRow2117 1000.000000
R22117 MemRRow2117 MemRRow2183 1000.000000
R22183 MemRRow2183 MemRRow2250 1000.000000
R22250 MemRRow2250 MemRRow2318 1000.000000
R22318 MemRRow2318 MemRRow2387 1000.000000
R22387 MemRRow2387 MemRRow2457 1000.000000
R22457 MemRRow2457 MemRRow2528 1000.000000
R22528 MemRRow2528 MemRRow2600 1000.000000
R22600 MemRRow2600 MemRRow2673 1000.000000
R22673 MemRRow2673 MemRRow2747 1000.000000
R22747 MemRRow2747 MemRRow2822 1000.000000
R22822 MemRRow2822 MemRRow2898 1000.000000
R22898 MemRRow2898 MemRRow2975 1000.000000
R22975 MemRRow2975 MemRRow3053 1000.000000
R23053 MemRRow3053 MemRRow3132 1000.000000
R2436 MemRRow436 MemRRow467 1000.000000
R2467 MemRRow467 MemRRow499 1000.000000
R2499 MemRRow499 MemRRow532 1000.000000
R2532 MemRRow532 MemRRow566 1000.000000
R2566 MemRRow566 MemRRow601 1000.000000
R2601 MemRRow601 MemRRow637 1000.000000
R2637 MemRRow637 MemRRow674 1000.000000
R2674 MemRRow674 MemRRow712 1000.000000
R2712 MemRRow712 MemRRow751 1000.000000
R2751 MemRRow751 MemRRow791 1000.000000
R2791 MemRRow791 MemRRow832 1000.000000
R2832 MemRRow832 MemRRow874 1000.000000
R2874 MemRRow874 MemRRow917 1000.000000
R2917 MemRRow917 MemRRow961 1000.000000
R2961 MemRRow961 MemRRow1006 1000.000000
R21006 MemRRow1006 MemRRow1052 1000.000000
R21052 MemRRow1052 MemRRow1099 1000.000000
R21099 MemRRow1099 MemRRow1147 1000.000000
R21147 MemRRow1147 MemRRow1196 1000.000000
R21196 MemRRow1196 MemRRow1246 1000.000000
R21246 MemRRow1246 MemRRow1297 1000.000000
R21297 MemRRow1297 MemRRow1349 1000.000000
R21349 MemRRow1349 MemRRow1402 1000.000000
R21402 MemRRow1402 MemRRow1456 1000.000000
R21456 MemRRow1456 MemRRow1511 1000.000000
R21511 MemRRow1511 MemRRow1567 1000.000000
R21567 MemRRow1567 MemRRow1624 1000.000000
R21624 MemRRow1624 MemRRow1682 1000.000000
R21682 MemRRow1682 MemRRow1741 1000.000000
R21741 MemRRow1741 MemRRow1801 1000.000000
R21801 MemRRow1801 MemRRow1862 1000.000000
R21862 MemRRow1862 MemRRow1924 1000.000000
R21924 MemRRow1924 MemRRow1987 1000.000000
R21987 MemRRow1987 MemRRow2051 1000.000000
R22051 MemRRow2051 MemRRow2116 1000.000000
R22116 MemRRow2116 MemRRow2182 1000.000000
R22182 MemRRow2182 MemRRow2249 1000.000000
R22249 MemRRow2249 MemRRow2317 1000.000000
R22317 MemRRow2317 MemRRow2386 1000.000000
R22386 MemRRow2386 MemRRow2456 1000.000000
R22456 MemRRow2456 MemRRow2527 1000.000000
R22527 MemRRow2527 MemRRow2599 1000.000000
R22599 MemRRow2599 MemRRow2672 1000.000000
R22672 MemRRow2672 MemRRow2746 1000.000000
R22746 MemRRow2746 MemRRow2821 1000.000000
R22821 MemRRow2821 MemRRow2897 1000.000000
R22897 MemRRow2897 MemRRow2974 1000.000000
R22974 MemRRow2974 MemRRow3052 1000.000000
R23052 MemRRow3052 MemRRow3131 1000.000000
R23131 MemRRow3131 MemRRow3211 1000.000000
R2466 MemRRow466 MemRRow498 1000.000000
R2498 MemRRow498 MemRRow531 1000.000000
R2531 MemRRow531 MemRRow565 1000.000000
R2565 MemRRow565 MemRRow600 1000.000000
R2600 MemRRow600 MemRRow636 1000.000000
R2636 MemRRow636 MemRRow673 1000.000000
R2673 MemRRow673 MemRRow711 1000.000000
R2711 MemRRow711 MemRRow750 1000.000000
R2750 MemRRow750 MemRRow790 1000.000000
R2790 MemRRow790 MemRRow831 1000.000000
R2831 MemRRow831 MemRRow873 1000.000000
R2873 MemRRow873 MemRRow916 1000.000000
R2916 MemRRow916 MemRRow960 1000.000000
R2960 MemRRow960 MemRRow1005 1000.000000
R21005 MemRRow1005 MemRRow1051 1000.000000
R21051 MemRRow1051 MemRRow1098 1000.000000
R21098 MemRRow1098 MemRRow1146 1000.000000
R21146 MemRRow1146 MemRRow1195 1000.000000
R21195 MemRRow1195 MemRRow1245 1000.000000
R21245 MemRRow1245 MemRRow1296 1000.000000
R21296 MemRRow1296 MemRRow1348 1000.000000
R21348 MemRRow1348 MemRRow1401 1000.000000
R21401 MemRRow1401 MemRRow1455 1000.000000
R21455 MemRRow1455 MemRRow1510 1000.000000
R21510 MemRRow1510 MemRRow1566 1000.000000
R21566 MemRRow1566 MemRRow1623 1000.000000
R21623 MemRRow1623 MemRRow1681 1000.000000
R21681 MemRRow1681 MemRRow1740 1000.000000
R21740 MemRRow1740 MemRRow1800 1000.000000
R21800 MemRRow1800 MemRRow1861 1000.000000
R21861 MemRRow1861 MemRRow1923 1000.000000
R21923 MemRRow1923 MemRRow1986 1000.000000
R21986 MemRRow1986 MemRRow2050 1000.000000
R22050 MemRRow2050 MemRRow2115 1000.000000
R22115 MemRRow2115 MemRRow2181 1000.000000
R22181 MemRRow2181 MemRRow2248 1000.000000
R22248 MemRRow2248 MemRRow2316 1000.000000
R22316 MemRRow2316 MemRRow2385 1000.000000
R22385 MemRRow2385 MemRRow2455 1000.000000
R22455 MemRRow2455 MemRRow2526 1000.000000
R22526 MemRRow2526 MemRRow2598 1000.000000
R22598 MemRRow2598 MemRRow2671 1000.000000
R22671 MemRRow2671 MemRRow2745 1000.000000
R22745 MemRRow2745 MemRRow2820 1000.000000
R22820 MemRRow2820 MemRRow2896 1000.000000
R22896 MemRRow2896 MemRRow2973 1000.000000
R22973 MemRRow2973 MemRRow3051 1000.000000
R23051 MemRRow3051 MemRRow3130 1000.000000
R23130 MemRRow3130 MemRRow3210 1000.000000
R23210 MemRRow3210 MemRRow3291 1000.000000
R2497 MemRRow497 MemRRow530 1000.000000
R2530 MemRRow530 MemRRow564 1000.000000
R2564 MemRRow564 MemRRow599 1000.000000
R2599 MemRRow599 MemRRow635 1000.000000
R2635 MemRRow635 MemRRow672 1000.000000
R2672 MemRRow672 MemRRow710 1000.000000
R2710 MemRRow710 MemRRow749 1000.000000
R2749 MemRRow749 MemRRow789 1000.000000
R2789 MemRRow789 MemRRow830 1000.000000
R2830 MemRRow830 MemRRow872 1000.000000
R2872 MemRRow872 MemRRow915 1000.000000
R2915 MemRRow915 MemRRow959 1000.000000
R2959 MemRRow959 MemRRow1004 1000.000000
R21004 MemRRow1004 MemRRow1050 1000.000000
R21050 MemRRow1050 MemRRow1097 1000.000000
R21097 MemRRow1097 MemRRow1145 1000.000000
R21145 MemRRow1145 MemRRow1194 1000.000000
R21194 MemRRow1194 MemRRow1244 1000.000000
R21244 MemRRow1244 MemRRow1295 1000.000000
R21295 MemRRow1295 MemRRow1347 1000.000000
R21347 MemRRow1347 MemRRow1400 1000.000000
R21400 MemRRow1400 MemRRow1454 1000.000000
R21454 MemRRow1454 MemRRow1509 1000.000000
R21509 MemRRow1509 MemRRow1565 1000.000000
R21565 MemRRow1565 MemRRow1622 1000.000000
R21622 MemRRow1622 MemRRow1680 1000.000000
R21680 MemRRow1680 MemRRow1739 1000.000000
R21739 MemRRow1739 MemRRow1799 1000.000000
R21799 MemRRow1799 MemRRow1860 1000.000000
R21860 MemRRow1860 MemRRow1922 1000.000000
R21922 MemRRow1922 MemRRow1985 1000.000000
R21985 MemRRow1985 MemRRow2049 1000.000000
R22049 MemRRow2049 MemRRow2114 1000.000000
R22114 MemRRow2114 MemRRow2180 1000.000000
R22180 MemRRow2180 MemRRow2247 1000.000000
R22247 MemRRow2247 MemRRow2315 1000.000000
R22315 MemRRow2315 MemRRow2384 1000.000000
R22384 MemRRow2384 MemRRow2454 1000.000000
R22454 MemRRow2454 MemRRow2525 1000.000000
R22525 MemRRow2525 MemRRow2597 1000.000000
R22597 MemRRow2597 MemRRow2670 1000.000000
R22670 MemRRow2670 MemRRow2744 1000.000000
R22744 MemRRow2744 MemRRow2819 1000.000000
R22819 MemRRow2819 MemRRow2895 1000.000000
R22895 MemRRow2895 MemRRow2972 1000.000000
R22972 MemRRow2972 MemRRow3050 1000.000000
R23050 MemRRow3050 MemRRow3129 1000.000000
R23129 MemRRow3129 MemRRow3209 1000.000000
R23209 MemRRow3209 MemRRow3290 1000.000000
R23290 MemRRow3290 MemRRow3372 1000.000000
R2529 MemRRow529 MemRRow563 1000.000000
R2563 MemRRow563 MemRRow598 1000.000000
R2598 MemRRow598 MemRRow634 1000.000000
R2634 MemRRow634 MemRRow671 1000.000000
R2671 MemRRow671 MemRRow709 1000.000000
R2709 MemRRow709 MemRRow748 1000.000000
R2748 MemRRow748 MemRRow788 1000.000000
R2788 MemRRow788 MemRRow829 1000.000000
R2829 MemRRow829 MemRRow871 1000.000000
R2871 MemRRow871 MemRRow914 1000.000000
R2914 MemRRow914 MemRRow958 1000.000000
R2958 MemRRow958 MemRRow1003 1000.000000
R21003 MemRRow1003 MemRRow1049 1000.000000
R21049 MemRRow1049 MemRRow1096 1000.000000
R21096 MemRRow1096 MemRRow1144 1000.000000
R21144 MemRRow1144 MemRRow1193 1000.000000
R21193 MemRRow1193 MemRRow1243 1000.000000
R21243 MemRRow1243 MemRRow1294 1000.000000
R21294 MemRRow1294 MemRRow1346 1000.000000
R21346 MemRRow1346 MemRRow1399 1000.000000
R21399 MemRRow1399 MemRRow1453 1000.000000
R21453 MemRRow1453 MemRRow1508 1000.000000
R21508 MemRRow1508 MemRRow1564 1000.000000
R21564 MemRRow1564 MemRRow1621 1000.000000
R21621 MemRRow1621 MemRRow1679 1000.000000
R21679 MemRRow1679 MemRRow1738 1000.000000
R21738 MemRRow1738 MemRRow1798 1000.000000
R21798 MemRRow1798 MemRRow1859 1000.000000
R21859 MemRRow1859 MemRRow1921 1000.000000
R21921 MemRRow1921 MemRRow1984 1000.000000
R21984 MemRRow1984 MemRRow2048 1000.000000
R22048 MemRRow2048 MemRRow2113 1000.000000
R22113 MemRRow2113 MemRRow2179 1000.000000
R22179 MemRRow2179 MemRRow2246 1000.000000
R22246 MemRRow2246 MemRRow2314 1000.000000
R22314 MemRRow2314 MemRRow2383 1000.000000
R22383 MemRRow2383 MemRRow2453 1000.000000
R22453 MemRRow2453 MemRRow2524 1000.000000
R22524 MemRRow2524 MemRRow2596 1000.000000
R22596 MemRRow2596 MemRRow2669 1000.000000
R22669 MemRRow2669 MemRRow2743 1000.000000
R22743 MemRRow2743 MemRRow2818 1000.000000
R22818 MemRRow2818 MemRRow2894 1000.000000
R22894 MemRRow2894 MemRRow2971 1000.000000
R22971 MemRRow2971 MemRRow3049 1000.000000
R23049 MemRRow3049 MemRRow3128 1000.000000
R23128 MemRRow3128 MemRRow3208 1000.000000
R23208 MemRRow3208 MemRRow3289 1000.000000
R23289 MemRRow3289 MemRRow3371 1000.000000
R23371 MemRRow3371 MemRRow3454 1000.000000
R2562 MemRRow562 MemRRow597 1000.000000
R2597 MemRRow597 MemRRow633 1000.000000
R2633 MemRRow633 MemRRow670 1000.000000
R2670 MemRRow670 MemRRow708 1000.000000
R2708 MemRRow708 MemRRow747 1000.000000
R2747 MemRRow747 MemRRow787 1000.000000
R2787 MemRRow787 MemRRow828 1000.000000
R2828 MemRRow828 MemRRow870 1000.000000
R2870 MemRRow870 MemRRow913 1000.000000
R2913 MemRRow913 MemRRow957 1000.000000
R2957 MemRRow957 MemRRow1002 1000.000000
R21002 MemRRow1002 MemRRow1048 1000.000000
R21048 MemRRow1048 MemRRow1095 1000.000000
R21095 MemRRow1095 MemRRow1143 1000.000000
R21143 MemRRow1143 MemRRow1192 1000.000000
R21192 MemRRow1192 MemRRow1242 1000.000000
R21242 MemRRow1242 MemRRow1293 1000.000000
R21293 MemRRow1293 MemRRow1345 1000.000000
R21345 MemRRow1345 MemRRow1398 1000.000000
R21398 MemRRow1398 MemRRow1452 1000.000000
R21452 MemRRow1452 MemRRow1507 1000.000000
R21507 MemRRow1507 MemRRow1563 1000.000000
R21563 MemRRow1563 MemRRow1620 1000.000000
R21620 MemRRow1620 MemRRow1678 1000.000000
R21678 MemRRow1678 MemRRow1737 1000.000000
R21737 MemRRow1737 MemRRow1797 1000.000000
R21797 MemRRow1797 MemRRow1858 1000.000000
R21858 MemRRow1858 MemRRow1920 1000.000000
R21920 MemRRow1920 MemRRow1983 1000.000000
R21983 MemRRow1983 MemRRow2047 1000.000000
R22047 MemRRow2047 MemRRow2112 1000.000000
R22112 MemRRow2112 MemRRow2178 1000.000000
R22178 MemRRow2178 MemRRow2245 1000.000000
R22245 MemRRow2245 MemRRow2313 1000.000000
R22313 MemRRow2313 MemRRow2382 1000.000000
R22382 MemRRow2382 MemRRow2452 1000.000000
R22452 MemRRow2452 MemRRow2523 1000.000000
R22523 MemRRow2523 MemRRow2595 1000.000000
R22595 MemRRow2595 MemRRow2668 1000.000000
R22668 MemRRow2668 MemRRow2742 1000.000000
R22742 MemRRow2742 MemRRow2817 1000.000000
R22817 MemRRow2817 MemRRow2893 1000.000000
R22893 MemRRow2893 MemRRow2970 1000.000000
R22970 MemRRow2970 MemRRow3048 1000.000000
R23048 MemRRow3048 MemRRow3127 1000.000000
R23127 MemRRow3127 MemRRow3207 1000.000000
R23207 MemRRow3207 MemRRow3288 1000.000000
R23288 MemRRow3288 MemRRow3370 1000.000000
R23370 MemRRow3370 MemRRow3453 1000.000000
R23453 MemRRow3453 MemRRow3537 1000.000000
R2596 MemRRow596 MemRRow632 1000.000000
R2632 MemRRow632 MemRRow669 1000.000000
R2669 MemRRow669 MemRRow707 1000.000000
R2707 MemRRow707 MemRRow746 1000.000000
R2746 MemRRow746 MemRRow786 1000.000000
R2786 MemRRow786 MemRRow827 1000.000000
R2827 MemRRow827 MemRRow869 1000.000000
R2869 MemRRow869 MemRRow912 1000.000000
R2912 MemRRow912 MemRRow956 1000.000000
R2956 MemRRow956 MemRRow1001 1000.000000
R21001 MemRRow1001 MemRRow1047 1000.000000
R21047 MemRRow1047 MemRRow1094 1000.000000
R21094 MemRRow1094 MemRRow1142 1000.000000
R21142 MemRRow1142 MemRRow1191 1000.000000
R21191 MemRRow1191 MemRRow1241 1000.000000
R21241 MemRRow1241 MemRRow1292 1000.000000
R21292 MemRRow1292 MemRRow1344 1000.000000
R21344 MemRRow1344 MemRRow1397 1000.000000
R21397 MemRRow1397 MemRRow1451 1000.000000
R21451 MemRRow1451 MemRRow1506 1000.000000
R21506 MemRRow1506 MemRRow1562 1000.000000
R21562 MemRRow1562 MemRRow1619 1000.000000
R21619 MemRRow1619 MemRRow1677 1000.000000
R21677 MemRRow1677 MemRRow1736 1000.000000
R21736 MemRRow1736 MemRRow1796 1000.000000
R21796 MemRRow1796 MemRRow1857 1000.000000
R21857 MemRRow1857 MemRRow1919 1000.000000
R21919 MemRRow1919 MemRRow1982 1000.000000
R21982 MemRRow1982 MemRRow2046 1000.000000
R22046 MemRRow2046 MemRRow2111 1000.000000
R22111 MemRRow2111 MemRRow2177 1000.000000
R22177 MemRRow2177 MemRRow2244 1000.000000
R22244 MemRRow2244 MemRRow2312 1000.000000
R22312 MemRRow2312 MemRRow2381 1000.000000
R22381 MemRRow2381 MemRRow2451 1000.000000
R22451 MemRRow2451 MemRRow2522 1000.000000
R22522 MemRRow2522 MemRRow2594 1000.000000
R22594 MemRRow2594 MemRRow2667 1000.000000
R22667 MemRRow2667 MemRRow2741 1000.000000
R22741 MemRRow2741 MemRRow2816 1000.000000
R22816 MemRRow2816 MemRRow2892 1000.000000
R22892 MemRRow2892 MemRRow2969 1000.000000
R22969 MemRRow2969 MemRRow3047 1000.000000
R23047 MemRRow3047 MemRRow3126 1000.000000
R23126 MemRRow3126 MemRRow3206 1000.000000
R23206 MemRRow3206 MemRRow3287 1000.000000
R23287 MemRRow3287 MemRRow3369 1000.000000
R23369 MemRRow3369 MemRRow3452 1000.000000
R23452 MemRRow3452 MemRRow3536 1000.000000
R23536 MemRRow3536 MemRRow3621 1000.000000
R2631 MemRRow631 MemRRow668 1000.000000
R2668 MemRRow668 MemRRow706 1000.000000
R2706 MemRRow706 MemRRow745 1000.000000
R2745 MemRRow745 MemRRow785 1000.000000
R2785 MemRRow785 MemRRow826 1000.000000
R2826 MemRRow826 MemRRow868 1000.000000
R2868 MemRRow868 MemRRow911 1000.000000
R2911 MemRRow911 MemRRow955 1000.000000
R2955 MemRRow955 MemRRow1000 1000.000000
R21000 MemRRow1000 MemRRow1046 1000.000000
R21046 MemRRow1046 MemRRow1093 1000.000000
R21093 MemRRow1093 MemRRow1141 1000.000000
R21141 MemRRow1141 MemRRow1190 1000.000000
R21190 MemRRow1190 MemRRow1240 1000.000000
R21240 MemRRow1240 MemRRow1291 1000.000000
R21291 MemRRow1291 MemRRow1343 1000.000000
R21343 MemRRow1343 MemRRow1396 1000.000000
R21396 MemRRow1396 MemRRow1450 1000.000000
R21450 MemRRow1450 MemRRow1505 1000.000000
R21505 MemRRow1505 MemRRow1561 1000.000000
R21561 MemRRow1561 MemRRow1618 1000.000000
R21618 MemRRow1618 MemRRow1676 1000.000000
R21676 MemRRow1676 MemRRow1735 1000.000000
R21735 MemRRow1735 MemRRow1795 1000.000000
R21795 MemRRow1795 MemRRow1856 1000.000000
R21856 MemRRow1856 MemRRow1918 1000.000000
R21918 MemRRow1918 MemRRow1981 1000.000000
R21981 MemRRow1981 MemRRow2045 1000.000000
R22045 MemRRow2045 MemRRow2110 1000.000000
R22110 MemRRow2110 MemRRow2176 1000.000000
R22176 MemRRow2176 MemRRow2243 1000.000000
R22243 MemRRow2243 MemRRow2311 1000.000000
R22311 MemRRow2311 MemRRow2380 1000.000000
R22380 MemRRow2380 MemRRow2450 1000.000000
R22450 MemRRow2450 MemRRow2521 1000.000000
R22521 MemRRow2521 MemRRow2593 1000.000000
R22593 MemRRow2593 MemRRow2666 1000.000000
R22666 MemRRow2666 MemRRow2740 1000.000000
R22740 MemRRow2740 MemRRow2815 1000.000000
R22815 MemRRow2815 MemRRow2891 1000.000000
R22891 MemRRow2891 MemRRow2968 1000.000000
R22968 MemRRow2968 MemRRow3046 1000.000000
R23046 MemRRow3046 MemRRow3125 1000.000000
R23125 MemRRow3125 MemRRow3205 1000.000000
R23205 MemRRow3205 MemRRow3286 1000.000000
R23286 MemRRow3286 MemRRow3368 1000.000000
R23368 MemRRow3368 MemRRow3451 1000.000000
R23451 MemRRow3451 MemRRow3535 1000.000000
R23535 MemRRow3535 MemRRow3620 1000.000000
R23620 MemRRow3620 MemRRow3706 1000.000000
R2667 MemRRow667 MemRRow705 1000.000000
R2705 MemRRow705 MemRRow744 1000.000000
R2744 MemRRow744 MemRRow784 1000.000000
R2784 MemRRow784 MemRRow825 1000.000000
R2825 MemRRow825 MemRRow867 1000.000000
R2867 MemRRow867 MemRRow910 1000.000000
R2910 MemRRow910 MemRRow954 1000.000000
R2954 MemRRow954 MemRRow999 1000.000000
R2999 MemRRow999 MemRRow1045 1000.000000
R21045 MemRRow1045 MemRRow1092 1000.000000
R21092 MemRRow1092 MemRRow1140 1000.000000
R21140 MemRRow1140 MemRRow1189 1000.000000
R21189 MemRRow1189 MemRRow1239 1000.000000
R21239 MemRRow1239 MemRRow1290 1000.000000
R21290 MemRRow1290 MemRRow1342 1000.000000
R21342 MemRRow1342 MemRRow1395 1000.000000
R21395 MemRRow1395 MemRRow1449 1000.000000
R21449 MemRRow1449 MemRRow1504 1000.000000
R21504 MemRRow1504 MemRRow1560 1000.000000
R21560 MemRRow1560 MemRRow1617 1000.000000
R21617 MemRRow1617 MemRRow1675 1000.000000
R21675 MemRRow1675 MemRRow1734 1000.000000
R21734 MemRRow1734 MemRRow1794 1000.000000
R21794 MemRRow1794 MemRRow1855 1000.000000
R21855 MemRRow1855 MemRRow1917 1000.000000
R21917 MemRRow1917 MemRRow1980 1000.000000
R21980 MemRRow1980 MemRRow2044 1000.000000
R22044 MemRRow2044 MemRRow2109 1000.000000
R22109 MemRRow2109 MemRRow2175 1000.000000
R22175 MemRRow2175 MemRRow2242 1000.000000
R22242 MemRRow2242 MemRRow2310 1000.000000
R22310 MemRRow2310 MemRRow2379 1000.000000
R22379 MemRRow2379 MemRRow2449 1000.000000
R22449 MemRRow2449 MemRRow2520 1000.000000
R22520 MemRRow2520 MemRRow2592 1000.000000
R22592 MemRRow2592 MemRRow2665 1000.000000
R22665 MemRRow2665 MemRRow2739 1000.000000
R22739 MemRRow2739 MemRRow2814 1000.000000
R22814 MemRRow2814 MemRRow2890 1000.000000
R22890 MemRRow2890 MemRRow2967 1000.000000
R22967 MemRRow2967 MemRRow3045 1000.000000
R23045 MemRRow3045 MemRRow3124 1000.000000
R23124 MemRRow3124 MemRRow3204 1000.000000
R23204 MemRRow3204 MemRRow3285 1000.000000
R23285 MemRRow3285 MemRRow3367 1000.000000
R23367 MemRRow3367 MemRRow3450 1000.000000
R23450 MemRRow3450 MemRRow3534 1000.000000
R23534 MemRRow3534 MemRRow3619 1000.000000
R23619 MemRRow3619 MemRRow3705 1000.000000
R23705 MemRRow3705 MemRRow3792 1000.000000
R2704 MemRRow704 MemRRow743 1000.000000
R2743 MemRRow743 MemRRow783 1000.000000
R2783 MemRRow783 MemRRow824 1000.000000
R2824 MemRRow824 MemRRow866 1000.000000
R2866 MemRRow866 MemRRow909 1000.000000
R2909 MemRRow909 MemRRow953 1000.000000
R2953 MemRRow953 MemRRow998 1000.000000
R2998 MemRRow998 MemRRow1044 1000.000000
R21044 MemRRow1044 MemRRow1091 1000.000000
R21091 MemRRow1091 MemRRow1139 1000.000000
R21139 MemRRow1139 MemRRow1188 1000.000000
R21188 MemRRow1188 MemRRow1238 1000.000000
R21238 MemRRow1238 MemRRow1289 1000.000000
R21289 MemRRow1289 MemRRow1341 1000.000000
R21341 MemRRow1341 MemRRow1394 1000.000000
R21394 MemRRow1394 MemRRow1448 1000.000000
R21448 MemRRow1448 MemRRow1503 1000.000000
R21503 MemRRow1503 MemRRow1559 1000.000000
R21559 MemRRow1559 MemRRow1616 1000.000000
R21616 MemRRow1616 MemRRow1674 1000.000000
R21674 MemRRow1674 MemRRow1733 1000.000000
R21733 MemRRow1733 MemRRow1793 1000.000000
R21793 MemRRow1793 MemRRow1854 1000.000000
R21854 MemRRow1854 MemRRow1916 1000.000000
R21916 MemRRow1916 MemRRow1979 1000.000000
R21979 MemRRow1979 MemRRow2043 1000.000000
R22043 MemRRow2043 MemRRow2108 1000.000000
R22108 MemRRow2108 MemRRow2174 1000.000000
R22174 MemRRow2174 MemRRow2241 1000.000000
R22241 MemRRow2241 MemRRow2309 1000.000000
R22309 MemRRow2309 MemRRow2378 1000.000000
R22378 MemRRow2378 MemRRow2448 1000.000000
R22448 MemRRow2448 MemRRow2519 1000.000000
R22519 MemRRow2519 MemRRow2591 1000.000000
R22591 MemRRow2591 MemRRow2664 1000.000000
R22664 MemRRow2664 MemRRow2738 1000.000000
R22738 MemRRow2738 MemRRow2813 1000.000000
R22813 MemRRow2813 MemRRow2889 1000.000000
R22889 MemRRow2889 MemRRow2966 1000.000000
R22966 MemRRow2966 MemRRow3044 1000.000000
R23044 MemRRow3044 MemRRow3123 1000.000000
R23123 MemRRow3123 MemRRow3203 1000.000000
R23203 MemRRow3203 MemRRow3284 1000.000000
R23284 MemRRow3284 MemRRow3366 1000.000000
R23366 MemRRow3366 MemRRow3449 1000.000000
R23449 MemRRow3449 MemRRow3533 1000.000000
R23533 MemRRow3533 MemRRow3618 1000.000000
R23618 MemRRow3618 MemRRow3704 1000.000000
R23704 MemRRow3704 MemRRow3791 1000.000000
R23791 MemRRow3791 MemRRow3879 1000.000000
R2742 MemRRow742 MemRRow782 1000.000000
R2782 MemRRow782 MemRRow823 1000.000000
R2823 MemRRow823 MemRRow865 1000.000000
R2865 MemRRow865 MemRRow908 1000.000000
R2908 MemRRow908 MemRRow952 1000.000000
R2952 MemRRow952 MemRRow997 1000.000000
R2997 MemRRow997 MemRRow1043 1000.000000
R21043 MemRRow1043 MemRRow1090 1000.000000
R21090 MemRRow1090 MemRRow1138 1000.000000
R21138 MemRRow1138 MemRRow1187 1000.000000
R21187 MemRRow1187 MemRRow1237 1000.000000
R21237 MemRRow1237 MemRRow1288 1000.000000
R21288 MemRRow1288 MemRRow1340 1000.000000
R21340 MemRRow1340 MemRRow1393 1000.000000
R21393 MemRRow1393 MemRRow1447 1000.000000
R21447 MemRRow1447 MemRRow1502 1000.000000
R21502 MemRRow1502 MemRRow1558 1000.000000
R21558 MemRRow1558 MemRRow1615 1000.000000
R21615 MemRRow1615 MemRRow1673 1000.000000
R21673 MemRRow1673 MemRRow1732 1000.000000
R21732 MemRRow1732 MemRRow1792 1000.000000
R21792 MemRRow1792 MemRRow1853 1000.000000
R21853 MemRRow1853 MemRRow1915 1000.000000
R21915 MemRRow1915 MemRRow1978 1000.000000
R21978 MemRRow1978 MemRRow2042 1000.000000
R22042 MemRRow2042 MemRRow2107 1000.000000
R22107 MemRRow2107 MemRRow2173 1000.000000
R22173 MemRRow2173 MemRRow2240 1000.000000
R22240 MemRRow2240 MemRRow2308 1000.000000
R22308 MemRRow2308 MemRRow2377 1000.000000
R22377 MemRRow2377 MemRRow2447 1000.000000
R22447 MemRRow2447 MemRRow2518 1000.000000
R22518 MemRRow2518 MemRRow2590 1000.000000
R22590 MemRRow2590 MemRRow2663 1000.000000
R22663 MemRRow2663 MemRRow2737 1000.000000
R22737 MemRRow2737 MemRRow2812 1000.000000
R22812 MemRRow2812 MemRRow2888 1000.000000
R22888 MemRRow2888 MemRRow2965 1000.000000
R22965 MemRRow2965 MemRRow3043 1000.000000
R23043 MemRRow3043 MemRRow3122 1000.000000
R23122 MemRRow3122 MemRRow3202 1000.000000
R23202 MemRRow3202 MemRRow3283 1000.000000
R23283 MemRRow3283 MemRRow3365 1000.000000
R23365 MemRRow3365 MemRRow3448 1000.000000
R23448 MemRRow3448 MemRRow3532 1000.000000
R23532 MemRRow3532 MemRRow3617 1000.000000
R23617 MemRRow3617 MemRRow3703 1000.000000
R23703 MemRRow3703 MemRRow3790 1000.000000
R23790 MemRRow3790 MemRRow3878 1000.000000
R23878 MemRRow3878 MemRRow3967 1000.000000
R2781 MemRRow781 MemRRow822 1000.000000
R2822 MemRRow822 MemRRow864 1000.000000
R2864 MemRRow864 MemRRow907 1000.000000
R2907 MemRRow907 MemRRow951 1000.000000
R2951 MemRRow951 MemRRow996 1000.000000
R2996 MemRRow996 MemRRow1042 1000.000000
R21042 MemRRow1042 MemRRow1089 1000.000000
R21089 MemRRow1089 MemRRow1137 1000.000000
R21137 MemRRow1137 MemRRow1186 1000.000000
R21186 MemRRow1186 MemRRow1236 1000.000000
R21236 MemRRow1236 MemRRow1287 1000.000000
R21287 MemRRow1287 MemRRow1339 1000.000000
R21339 MemRRow1339 MemRRow1392 1000.000000
R21392 MemRRow1392 MemRRow1446 1000.000000
R21446 MemRRow1446 MemRRow1501 1000.000000
R21501 MemRRow1501 MemRRow1557 1000.000000
R21557 MemRRow1557 MemRRow1614 1000.000000
R21614 MemRRow1614 MemRRow1672 1000.000000
R21672 MemRRow1672 MemRRow1731 1000.000000
R21731 MemRRow1731 MemRRow1791 1000.000000
R21791 MemRRow1791 MemRRow1852 1000.000000
R21852 MemRRow1852 MemRRow1914 1000.000000
R21914 MemRRow1914 MemRRow1977 1000.000000
R21977 MemRRow1977 MemRRow2041 1000.000000
R22041 MemRRow2041 MemRRow2106 1000.000000
R22106 MemRRow2106 MemRRow2172 1000.000000
R22172 MemRRow2172 MemRRow2239 1000.000000
R22239 MemRRow2239 MemRRow2307 1000.000000
R22307 MemRRow2307 MemRRow2376 1000.000000
R22376 MemRRow2376 MemRRow2446 1000.000000
R22446 MemRRow2446 MemRRow2517 1000.000000
R22517 MemRRow2517 MemRRow2589 1000.000000
R22589 MemRRow2589 MemRRow2662 1000.000000
R22662 MemRRow2662 MemRRow2736 1000.000000
R22736 MemRRow2736 MemRRow2811 1000.000000
R22811 MemRRow2811 MemRRow2887 1000.000000
R22887 MemRRow2887 MemRRow2964 1000.000000
R22964 MemRRow2964 MemRRow3042 1000.000000
R23042 MemRRow3042 MemRRow3121 1000.000000
R23121 MemRRow3121 MemRRow3201 1000.000000
R23201 MemRRow3201 MemRRow3282 1000.000000
R23282 MemRRow3282 MemRRow3364 1000.000000
R23364 MemRRow3364 MemRRow3447 1000.000000
R23447 MemRRow3447 MemRRow3531 1000.000000
R23531 MemRRow3531 MemRRow3616 1000.000000
R23616 MemRRow3616 MemRRow3702 1000.000000
R23702 MemRRow3702 MemRRow3789 1000.000000
R23789 MemRRow3789 MemRRow3877 1000.000000
R23877 MemRRow3877 MemRRow3966 1000.000000
R23966 MemRRow3966 MemRRow4056 1000.000000
R2821 MemRRow821 MemRRow863 1000.000000
R2863 MemRRow863 MemRRow906 1000.000000
R2906 MemRRow906 MemRRow950 1000.000000
R2950 MemRRow950 MemRRow995 1000.000000
R2995 MemRRow995 MemRRow1041 1000.000000
R21041 MemRRow1041 MemRRow1088 1000.000000
R21088 MemRRow1088 MemRRow1136 1000.000000
R21136 MemRRow1136 MemRRow1185 1000.000000
R21185 MemRRow1185 MemRRow1235 1000.000000
R21235 MemRRow1235 MemRRow1286 1000.000000
R21286 MemRRow1286 MemRRow1338 1000.000000
R21338 MemRRow1338 MemRRow1391 1000.000000
R21391 MemRRow1391 MemRRow1445 1000.000000
R21445 MemRRow1445 MemRRow1500 1000.000000
R21500 MemRRow1500 MemRRow1556 1000.000000
R21556 MemRRow1556 MemRRow1613 1000.000000
R21613 MemRRow1613 MemRRow1671 1000.000000
R21671 MemRRow1671 MemRRow1730 1000.000000
R21730 MemRRow1730 MemRRow1790 1000.000000
R21790 MemRRow1790 MemRRow1851 1000.000000
R21851 MemRRow1851 MemRRow1913 1000.000000
R21913 MemRRow1913 MemRRow1976 1000.000000
R21976 MemRRow1976 MemRRow2040 1000.000000
R22040 MemRRow2040 MemRRow2105 1000.000000
R22105 MemRRow2105 MemRRow2171 1000.000000
R22171 MemRRow2171 MemRRow2238 1000.000000
R22238 MemRRow2238 MemRRow2306 1000.000000
R22306 MemRRow2306 MemRRow2375 1000.000000
R22375 MemRRow2375 MemRRow2445 1000.000000
R22445 MemRRow2445 MemRRow2516 1000.000000
R22516 MemRRow2516 MemRRow2588 1000.000000
R22588 MemRRow2588 MemRRow2661 1000.000000
R22661 MemRRow2661 MemRRow2735 1000.000000
R22735 MemRRow2735 MemRRow2810 1000.000000
R22810 MemRRow2810 MemRRow2886 1000.000000
R22886 MemRRow2886 MemRRow2963 1000.000000
R22963 MemRRow2963 MemRRow3041 1000.000000
R23041 MemRRow3041 MemRRow3120 1000.000000
R23120 MemRRow3120 MemRRow3200 1000.000000
R23200 MemRRow3200 MemRRow3281 1000.000000
R23281 MemRRow3281 MemRRow3363 1000.000000
R23363 MemRRow3363 MemRRow3446 1000.000000
R23446 MemRRow3446 MemRRow3530 1000.000000
R23530 MemRRow3530 MemRRow3615 1000.000000
R23615 MemRRow3615 MemRRow3701 1000.000000
R23701 MemRRow3701 MemRRow3788 1000.000000
R23788 MemRRow3788 MemRRow3876 1000.000000
R23876 MemRRow3876 MemRRow3965 1000.000000
R23965 MemRRow3965 MemRRow4055 1000.000000
R24055 MemRRow4055 MemRRow4146 1000.000000
R2862 MemRRow862 MemRRow905 1000.000000
R2905 MemRRow905 MemRRow949 1000.000000
R2949 MemRRow949 MemRRow994 1000.000000
R2994 MemRRow994 MemRRow1040 1000.000000
R21040 MemRRow1040 MemRRow1087 1000.000000
R21087 MemRRow1087 MemRRow1135 1000.000000
R21135 MemRRow1135 MemRRow1184 1000.000000
R21184 MemRRow1184 MemRRow1234 1000.000000
R21234 MemRRow1234 MemRRow1285 1000.000000
R21285 MemRRow1285 MemRRow1337 1000.000000
R21337 MemRRow1337 MemRRow1390 1000.000000
R21390 MemRRow1390 MemRRow1444 1000.000000
R21444 MemRRow1444 MemRRow1499 1000.000000
R21499 MemRRow1499 MemRRow1555 1000.000000
R21555 MemRRow1555 MemRRow1612 1000.000000
R21612 MemRRow1612 MemRRow1670 1000.000000
R21670 MemRRow1670 MemRRow1729 1000.000000
R21729 MemRRow1729 MemRRow1789 1000.000000
R21789 MemRRow1789 MemRRow1850 1000.000000
R21850 MemRRow1850 MemRRow1912 1000.000000
R21912 MemRRow1912 MemRRow1975 1000.000000
R21975 MemRRow1975 MemRRow2039 1000.000000
R22039 MemRRow2039 MemRRow2104 1000.000000
R22104 MemRRow2104 MemRRow2170 1000.000000
R22170 MemRRow2170 MemRRow2237 1000.000000
R22237 MemRRow2237 MemRRow2305 1000.000000
R22305 MemRRow2305 MemRRow2374 1000.000000
R22374 MemRRow2374 MemRRow2444 1000.000000
R22444 MemRRow2444 MemRRow2515 1000.000000
R22515 MemRRow2515 MemRRow2587 1000.000000
R22587 MemRRow2587 MemRRow2660 1000.000000
R22660 MemRRow2660 MemRRow2734 1000.000000
R22734 MemRRow2734 MemRRow2809 1000.000000
R22809 MemRRow2809 MemRRow2885 1000.000000
R22885 MemRRow2885 MemRRow2962 1000.000000
R22962 MemRRow2962 MemRRow3040 1000.000000
R23040 MemRRow3040 MemRRow3119 1000.000000
R23119 MemRRow3119 MemRRow3199 1000.000000
R23199 MemRRow3199 MemRRow3280 1000.000000
R23280 MemRRow3280 MemRRow3362 1000.000000
R23362 MemRRow3362 MemRRow3445 1000.000000
R23445 MemRRow3445 MemRRow3529 1000.000000
R23529 MemRRow3529 MemRRow3614 1000.000000
R23614 MemRRow3614 MemRRow3700 1000.000000
R23700 MemRRow3700 MemRRow3787 1000.000000
R23787 MemRRow3787 MemRRow3875 1000.000000
R23875 MemRRow3875 MemRRow3964 1000.000000
R23964 MemRRow3964 MemRRow4054 1000.000000
R24054 MemRRow4054 MemRRow4145 1000.000000
R24145 MemRRow4145 MemRRow4237 1000.000000
R2904 MemRRow904 MemRRow948 1000.000000
R2948 MemRRow948 MemRRow993 1000.000000
R2993 MemRRow993 MemRRow1039 1000.000000
R21039 MemRRow1039 MemRRow1086 1000.000000
R21086 MemRRow1086 MemRRow1134 1000.000000
R21134 MemRRow1134 MemRRow1183 1000.000000
R21183 MemRRow1183 MemRRow1233 1000.000000
R21233 MemRRow1233 MemRRow1284 1000.000000
R21284 MemRRow1284 MemRRow1336 1000.000000
R21336 MemRRow1336 MemRRow1389 1000.000000
R21389 MemRRow1389 MemRRow1443 1000.000000
R21443 MemRRow1443 MemRRow1498 1000.000000
R21498 MemRRow1498 MemRRow1554 1000.000000
R21554 MemRRow1554 MemRRow1611 1000.000000
R21611 MemRRow1611 MemRRow1669 1000.000000
R21669 MemRRow1669 MemRRow1728 1000.000000
R21728 MemRRow1728 MemRRow1788 1000.000000
R21788 MemRRow1788 MemRRow1849 1000.000000
R21849 MemRRow1849 MemRRow1911 1000.000000
R21911 MemRRow1911 MemRRow1974 1000.000000
R21974 MemRRow1974 MemRRow2038 1000.000000
R22038 MemRRow2038 MemRRow2103 1000.000000
R22103 MemRRow2103 MemRRow2169 1000.000000
R22169 MemRRow2169 MemRRow2236 1000.000000
R22236 MemRRow2236 MemRRow2304 1000.000000
R22304 MemRRow2304 MemRRow2373 1000.000000
R22373 MemRRow2373 MemRRow2443 1000.000000
R22443 MemRRow2443 MemRRow2514 1000.000000
R22514 MemRRow2514 MemRRow2586 1000.000000
R22586 MemRRow2586 MemRRow2659 1000.000000
R22659 MemRRow2659 MemRRow2733 1000.000000
R22733 MemRRow2733 MemRRow2808 1000.000000
R22808 MemRRow2808 MemRRow2884 1000.000000
R22884 MemRRow2884 MemRRow2961 1000.000000
R22961 MemRRow2961 MemRRow3039 1000.000000
R23039 MemRRow3039 MemRRow3118 1000.000000
R23118 MemRRow3118 MemRRow3198 1000.000000
R23198 MemRRow3198 MemRRow3279 1000.000000
R23279 MemRRow3279 MemRRow3361 1000.000000
R23361 MemRRow3361 MemRRow3444 1000.000000
R23444 MemRRow3444 MemRRow3528 1000.000000
R23528 MemRRow3528 MemRRow3613 1000.000000
R23613 MemRRow3613 MemRRow3699 1000.000000
R23699 MemRRow3699 MemRRow3786 1000.000000
R23786 MemRRow3786 MemRRow3874 1000.000000
R23874 MemRRow3874 MemRRow3963 1000.000000
R23963 MemRRow3963 MemRRow4053 1000.000000
R24053 MemRRow4053 MemRRow4144 1000.000000
R24144 MemRRow4144 MemRRow4236 1000.000000
R24236 MemRRow4236 MemRRow4329 1000.000000
R2947 MemRRow947 MemRRow992 1000.000000
R2992 MemRRow992 MemRRow1038 1000.000000
R21038 MemRRow1038 MemRRow1085 1000.000000
R21085 MemRRow1085 MemRRow1133 1000.000000
R21133 MemRRow1133 MemRRow1182 1000.000000
R21182 MemRRow1182 MemRRow1232 1000.000000
R21232 MemRRow1232 MemRRow1283 1000.000000
R21283 MemRRow1283 MemRRow1335 1000.000000
R21335 MemRRow1335 MemRRow1388 1000.000000
R21388 MemRRow1388 MemRRow1442 1000.000000
R21442 MemRRow1442 MemRRow1497 1000.000000
R21497 MemRRow1497 MemRRow1553 1000.000000
R21553 MemRRow1553 MemRRow1610 1000.000000
R21610 MemRRow1610 MemRRow1668 1000.000000
R21668 MemRRow1668 MemRRow1727 1000.000000
R21727 MemRRow1727 MemRRow1787 1000.000000
R21787 MemRRow1787 MemRRow1848 1000.000000
R21848 MemRRow1848 MemRRow1910 1000.000000
R21910 MemRRow1910 MemRRow1973 1000.000000
R21973 MemRRow1973 MemRRow2037 1000.000000
R22037 MemRRow2037 MemRRow2102 1000.000000
R22102 MemRRow2102 MemRRow2168 1000.000000
R22168 MemRRow2168 MemRRow2235 1000.000000
R22235 MemRRow2235 MemRRow2303 1000.000000
R22303 MemRRow2303 MemRRow2372 1000.000000
R22372 MemRRow2372 MemRRow2442 1000.000000
R22442 MemRRow2442 MemRRow2513 1000.000000
R22513 MemRRow2513 MemRRow2585 1000.000000
R22585 MemRRow2585 MemRRow2658 1000.000000
R22658 MemRRow2658 MemRRow2732 1000.000000
R22732 MemRRow2732 MemRRow2807 1000.000000
R22807 MemRRow2807 MemRRow2883 1000.000000
R22883 MemRRow2883 MemRRow2960 1000.000000
R22960 MemRRow2960 MemRRow3038 1000.000000
R23038 MemRRow3038 MemRRow3117 1000.000000
R23117 MemRRow3117 MemRRow3197 1000.000000
R23197 MemRRow3197 MemRRow3278 1000.000000
R23278 MemRRow3278 MemRRow3360 1000.000000
R23360 MemRRow3360 MemRRow3443 1000.000000
R23443 MemRRow3443 MemRRow3527 1000.000000
R23527 MemRRow3527 MemRRow3612 1000.000000
R23612 MemRRow3612 MemRRow3698 1000.000000
R23698 MemRRow3698 MemRRow3785 1000.000000
R23785 MemRRow3785 MemRRow3873 1000.000000
R23873 MemRRow3873 MemRRow3962 1000.000000
R23962 MemRRow3962 MemRRow4052 1000.000000
R24052 MemRRow4052 MemRRow4143 1000.000000
R24143 MemRRow4143 MemRRow4235 1000.000000
R24235 MemRRow4235 MemRRow4328 1000.000000
R24328 MemRRow4328 MemRRow4422 1000.000000
R2991 MemRRow991 MemRRow1037 1000.000000
R21037 MemRRow1037 MemRRow1084 1000.000000
R21084 MemRRow1084 MemRRow1132 1000.000000
R21132 MemRRow1132 MemRRow1181 1000.000000
R21181 MemRRow1181 MemRRow1231 1000.000000
R21231 MemRRow1231 MemRRow1282 1000.000000
R21282 MemRRow1282 MemRRow1334 1000.000000
R21334 MemRRow1334 MemRRow1387 1000.000000
R21387 MemRRow1387 MemRRow1441 1000.000000
R21441 MemRRow1441 MemRRow1496 1000.000000
R21496 MemRRow1496 MemRRow1552 1000.000000
R21552 MemRRow1552 MemRRow1609 1000.000000
R21609 MemRRow1609 MemRRow1667 1000.000000
R21667 MemRRow1667 MemRRow1726 1000.000000
R21726 MemRRow1726 MemRRow1786 1000.000000
R21786 MemRRow1786 MemRRow1847 1000.000000
R21847 MemRRow1847 MemRRow1909 1000.000000
R21909 MemRRow1909 MemRRow1972 1000.000000
R21972 MemRRow1972 MemRRow2036 1000.000000
R22036 MemRRow2036 MemRRow2101 1000.000000
R22101 MemRRow2101 MemRRow2167 1000.000000
R22167 MemRRow2167 MemRRow2234 1000.000000
R22234 MemRRow2234 MemRRow2302 1000.000000
R22302 MemRRow2302 MemRRow2371 1000.000000
R22371 MemRRow2371 MemRRow2441 1000.000000
R22441 MemRRow2441 MemRRow2512 1000.000000
R22512 MemRRow2512 MemRRow2584 1000.000000
R22584 MemRRow2584 MemRRow2657 1000.000000
R22657 MemRRow2657 MemRRow2731 1000.000000
R22731 MemRRow2731 MemRRow2806 1000.000000
R22806 MemRRow2806 MemRRow2882 1000.000000
R22882 MemRRow2882 MemRRow2959 1000.000000
R22959 MemRRow2959 MemRRow3037 1000.000000
R23037 MemRRow3037 MemRRow3116 1000.000000
R23116 MemRRow3116 MemRRow3196 1000.000000
R23196 MemRRow3196 MemRRow3277 1000.000000
R23277 MemRRow3277 MemRRow3359 1000.000000
R23359 MemRRow3359 MemRRow3442 1000.000000
R23442 MemRRow3442 MemRRow3526 1000.000000
R23526 MemRRow3526 MemRRow3611 1000.000000
R23611 MemRRow3611 MemRRow3697 1000.000000
R23697 MemRRow3697 MemRRow3784 1000.000000
R23784 MemRRow3784 MemRRow3872 1000.000000
R23872 MemRRow3872 MemRRow3961 1000.000000
R23961 MemRRow3961 MemRRow4051 1000.000000
R24051 MemRRow4051 MemRRow4142 1000.000000
R24142 MemRRow4142 MemRRow4234 1000.000000
R24234 MemRRow4234 MemRRow4327 1000.000000
R24327 MemRRow4327 MemRRow4421 1000.000000
R24421 MemRRow4421 MemRRow4516 1000.000000
R21036 MemRRow1036 MemRRow1083 1000.000000
R21083 MemRRow1083 MemRRow1131 1000.000000
R21131 MemRRow1131 MemRRow1180 1000.000000
R21180 MemRRow1180 MemRRow1230 1000.000000
R21230 MemRRow1230 MemRRow1281 1000.000000
R21281 MemRRow1281 MemRRow1333 1000.000000
R21333 MemRRow1333 MemRRow1386 1000.000000
R21386 MemRRow1386 MemRRow1440 1000.000000
R21440 MemRRow1440 MemRRow1495 1000.000000
R21495 MemRRow1495 MemRRow1551 1000.000000
R21551 MemRRow1551 MemRRow1608 1000.000000
R21608 MemRRow1608 MemRRow1666 1000.000000
R21666 MemRRow1666 MemRRow1725 1000.000000
R21725 MemRRow1725 MemRRow1785 1000.000000
R21785 MemRRow1785 MemRRow1846 1000.000000
R21846 MemRRow1846 MemRRow1908 1000.000000
R21908 MemRRow1908 MemRRow1971 1000.000000
R21971 MemRRow1971 MemRRow2035 1000.000000
R22035 MemRRow2035 MemRRow2100 1000.000000
R22100 MemRRow2100 MemRRow2166 1000.000000
R22166 MemRRow2166 MemRRow2233 1000.000000
R22233 MemRRow2233 MemRRow2301 1000.000000
R22301 MemRRow2301 MemRRow2370 1000.000000
R22370 MemRRow2370 MemRRow2440 1000.000000
R22440 MemRRow2440 MemRRow2511 1000.000000
R22511 MemRRow2511 MemRRow2583 1000.000000
R22583 MemRRow2583 MemRRow2656 1000.000000
R22656 MemRRow2656 MemRRow2730 1000.000000
R22730 MemRRow2730 MemRRow2805 1000.000000
R22805 MemRRow2805 MemRRow2881 1000.000000
R22881 MemRRow2881 MemRRow2958 1000.000000
R22958 MemRRow2958 MemRRow3036 1000.000000
R23036 MemRRow3036 MemRRow3115 1000.000000
R23115 MemRRow3115 MemRRow3195 1000.000000
R23195 MemRRow3195 MemRRow3276 1000.000000
R23276 MemRRow3276 MemRRow3358 1000.000000
R23358 MemRRow3358 MemRRow3441 1000.000000
R23441 MemRRow3441 MemRRow3525 1000.000000
R23525 MemRRow3525 MemRRow3610 1000.000000
R23610 MemRRow3610 MemRRow3696 1000.000000
R23696 MemRRow3696 MemRRow3783 1000.000000
R23783 MemRRow3783 MemRRow3871 1000.000000
R23871 MemRRow3871 MemRRow3960 1000.000000
R23960 MemRRow3960 MemRRow4050 1000.000000
R24050 MemRRow4050 MemRRow4141 1000.000000
R24141 MemRRow4141 MemRRow4233 1000.000000
R24233 MemRRow4233 MemRRow4326 1000.000000
R24326 MemRRow4326 MemRRow4420 1000.000000
R24420 MemRRow4420 MemRRow4515 1000.000000
R24515 MemRRow4515 MemRRow4611 1000.000000
R21082 MemRRow1082 MemRRow1130 1000.000000
R21130 MemRRow1130 MemRRow1179 1000.000000
R21179 MemRRow1179 MemRRow1229 1000.000000
R21229 MemRRow1229 MemRRow1280 1000.000000
R21280 MemRRow1280 MemRRow1332 1000.000000
R21332 MemRRow1332 MemRRow1385 1000.000000
R21385 MemRRow1385 MemRRow1439 1000.000000
R21439 MemRRow1439 MemRRow1494 1000.000000
R21494 MemRRow1494 MemRRow1550 1000.000000
R21550 MemRRow1550 MemRRow1607 1000.000000
R21607 MemRRow1607 MemRRow1665 1000.000000
R21665 MemRRow1665 MemRRow1724 1000.000000
R21724 MemRRow1724 MemRRow1784 1000.000000
R21784 MemRRow1784 MemRRow1845 1000.000000
R21845 MemRRow1845 MemRRow1907 1000.000000
R21907 MemRRow1907 MemRRow1970 1000.000000
R21970 MemRRow1970 MemRRow2034 1000.000000
R22034 MemRRow2034 MemRRow2099 1000.000000
R22099 MemRRow2099 MemRRow2165 1000.000000
R22165 MemRRow2165 MemRRow2232 1000.000000
R22232 MemRRow2232 MemRRow2300 1000.000000
R22300 MemRRow2300 MemRRow2369 1000.000000
R22369 MemRRow2369 MemRRow2439 1000.000000
R22439 MemRRow2439 MemRRow2510 1000.000000
R22510 MemRRow2510 MemRRow2582 1000.000000
R22582 MemRRow2582 MemRRow2655 1000.000000
R22655 MemRRow2655 MemRRow2729 1000.000000
R22729 MemRRow2729 MemRRow2804 1000.000000
R22804 MemRRow2804 MemRRow2880 1000.000000
R22880 MemRRow2880 MemRRow2957 1000.000000
R22957 MemRRow2957 MemRRow3035 1000.000000
R23035 MemRRow3035 MemRRow3114 1000.000000
R23114 MemRRow3114 MemRRow3194 1000.000000
R23194 MemRRow3194 MemRRow3275 1000.000000
R23275 MemRRow3275 MemRRow3357 1000.000000
R23357 MemRRow3357 MemRRow3440 1000.000000
R23440 MemRRow3440 MemRRow3524 1000.000000
R23524 MemRRow3524 MemRRow3609 1000.000000
R23609 MemRRow3609 MemRRow3695 1000.000000
R23695 MemRRow3695 MemRRow3782 1000.000000
R23782 MemRRow3782 MemRRow3870 1000.000000
R23870 MemRRow3870 MemRRow3959 1000.000000
R23959 MemRRow3959 MemRRow4049 1000.000000
R24049 MemRRow4049 MemRRow4140 1000.000000
R24140 MemRRow4140 MemRRow4232 1000.000000
R24232 MemRRow4232 MemRRow4325 1000.000000
R24325 MemRRow4325 MemRRow4419 1000.000000
R24419 MemRRow4419 MemRRow4514 1000.000000
R24514 MemRRow4514 MemRRow4610 1000.000000
R24610 MemRRow4610 MemRRow4707 1000.000000
R21129 MemRRow1129 MemRRow1178 1000.000000
R21178 MemRRow1178 MemRRow1228 1000.000000
R21228 MemRRow1228 MemRRow1279 1000.000000
R21279 MemRRow1279 MemRRow1331 1000.000000
R21331 MemRRow1331 MemRRow1384 1000.000000
R21384 MemRRow1384 MemRRow1438 1000.000000
R21438 MemRRow1438 MemRRow1493 1000.000000
R21493 MemRRow1493 MemRRow1549 1000.000000
R21549 MemRRow1549 MemRRow1606 1000.000000
R21606 MemRRow1606 MemRRow1664 1000.000000
R21664 MemRRow1664 MemRRow1723 1000.000000
R21723 MemRRow1723 MemRRow1783 1000.000000
R21783 MemRRow1783 MemRRow1844 1000.000000
R21844 MemRRow1844 MemRRow1906 1000.000000
R21906 MemRRow1906 MemRRow1969 1000.000000
R21969 MemRRow1969 MemRRow2033 1000.000000
R22033 MemRRow2033 MemRRow2098 1000.000000
R22098 MemRRow2098 MemRRow2164 1000.000000
R22164 MemRRow2164 MemRRow2231 1000.000000
R22231 MemRRow2231 MemRRow2299 1000.000000
R22299 MemRRow2299 MemRRow2368 1000.000000
R22368 MemRRow2368 MemRRow2438 1000.000000
R22438 MemRRow2438 MemRRow2509 1000.000000
R22509 MemRRow2509 MemRRow2581 1000.000000
R22581 MemRRow2581 MemRRow2654 1000.000000
R22654 MemRRow2654 MemRRow2728 1000.000000
R22728 MemRRow2728 MemRRow2803 1000.000000
R22803 MemRRow2803 MemRRow2879 1000.000000
R22879 MemRRow2879 MemRRow2956 1000.000000
R22956 MemRRow2956 MemRRow3034 1000.000000
R23034 MemRRow3034 MemRRow3113 1000.000000
R23113 MemRRow3113 MemRRow3193 1000.000000
R23193 MemRRow3193 MemRRow3274 1000.000000
R23274 MemRRow3274 MemRRow3356 1000.000000
R23356 MemRRow3356 MemRRow3439 1000.000000
R23439 MemRRow3439 MemRRow3523 1000.000000
R23523 MemRRow3523 MemRRow3608 1000.000000
R23608 MemRRow3608 MemRRow3694 1000.000000
R23694 MemRRow3694 MemRRow3781 1000.000000
R23781 MemRRow3781 MemRRow3869 1000.000000
R23869 MemRRow3869 MemRRow3958 1000.000000
R23958 MemRRow3958 MemRRow4048 1000.000000
R24048 MemRRow4048 MemRRow4139 1000.000000
R24139 MemRRow4139 MemRRow4231 1000.000000
R24231 MemRRow4231 MemRRow4324 1000.000000
R24324 MemRRow4324 MemRRow4418 1000.000000
R24418 MemRRow4418 MemRRow4513 1000.000000
R24513 MemRRow4513 MemRRow4609 1000.000000
R24609 MemRRow4609 MemRRow4706 1000.000000
R24706 MemRRow4706 MemRRow4804 1000.000000
R21177 MemRRow1177 MemRRow1227 1000.000000
R21227 MemRRow1227 MemRRow1278 1000.000000
R21278 MemRRow1278 MemRRow1330 1000.000000
R21330 MemRRow1330 MemRRow1383 1000.000000
R21383 MemRRow1383 MemRRow1437 1000.000000
R21437 MemRRow1437 MemRRow1492 1000.000000
R21492 MemRRow1492 MemRRow1548 1000.000000
R21548 MemRRow1548 MemRRow1605 1000.000000
R21605 MemRRow1605 MemRRow1663 1000.000000
R21663 MemRRow1663 MemRRow1722 1000.000000
R21722 MemRRow1722 MemRRow1782 1000.000000
R21782 MemRRow1782 MemRRow1843 1000.000000
R21843 MemRRow1843 MemRRow1905 1000.000000
R21905 MemRRow1905 MemRRow1968 1000.000000
R21968 MemRRow1968 MemRRow2032 1000.000000
R22032 MemRRow2032 MemRRow2097 1000.000000
R22097 MemRRow2097 MemRRow2163 1000.000000
R22163 MemRRow2163 MemRRow2230 1000.000000
R22230 MemRRow2230 MemRRow2298 1000.000000
R22298 MemRRow2298 MemRRow2367 1000.000000
R22367 MemRRow2367 MemRRow2437 1000.000000
R22437 MemRRow2437 MemRRow2508 1000.000000
R22508 MemRRow2508 MemRRow2580 1000.000000
R22580 MemRRow2580 MemRRow2653 1000.000000
R22653 MemRRow2653 MemRRow2727 1000.000000
R22727 MemRRow2727 MemRRow2802 1000.000000
R22802 MemRRow2802 MemRRow2878 1000.000000
R22878 MemRRow2878 MemRRow2955 1000.000000
R22955 MemRRow2955 MemRRow3033 1000.000000
R23033 MemRRow3033 MemRRow3112 1000.000000
R23112 MemRRow3112 MemRRow3192 1000.000000
R23192 MemRRow3192 MemRRow3273 1000.000000
R23273 MemRRow3273 MemRRow3355 1000.000000
R23355 MemRRow3355 MemRRow3438 1000.000000
R23438 MemRRow3438 MemRRow3522 1000.000000
R23522 MemRRow3522 MemRRow3607 1000.000000
R23607 MemRRow3607 MemRRow3693 1000.000000
R23693 MemRRow3693 MemRRow3780 1000.000000
R23780 MemRRow3780 MemRRow3868 1000.000000
R23868 MemRRow3868 MemRRow3957 1000.000000
R23957 MemRRow3957 MemRRow4047 1000.000000
R24047 MemRRow4047 MemRRow4138 1000.000000
R24138 MemRRow4138 MemRRow4230 1000.000000
R24230 MemRRow4230 MemRRow4323 1000.000000
R24323 MemRRow4323 MemRRow4417 1000.000000
R24417 MemRRow4417 MemRRow4512 1000.000000
R24512 MemRRow4512 MemRRow4608 1000.000000
R24608 MemRRow4608 MemRRow4705 1000.000000
R24705 MemRRow4705 MemRRow4803 1000.000000
R24803 MemRRow4803 MemRRow4902 1000.000000
R21226 MemRRow1226 MemRRow1277 1000.000000
R21277 MemRRow1277 MemRRow1329 1000.000000
R21329 MemRRow1329 MemRRow1382 1000.000000
R21382 MemRRow1382 MemRRow1436 1000.000000
R21436 MemRRow1436 MemRRow1491 1000.000000
R21491 MemRRow1491 MemRRow1547 1000.000000
R21547 MemRRow1547 MemRRow1604 1000.000000
R21604 MemRRow1604 MemRRow1662 1000.000000
R21662 MemRRow1662 MemRRow1721 1000.000000
R21721 MemRRow1721 MemRRow1781 1000.000000
R21781 MemRRow1781 MemRRow1842 1000.000000
R21842 MemRRow1842 MemRRow1904 1000.000000
R21904 MemRRow1904 MemRRow1967 1000.000000
R21967 MemRRow1967 MemRRow2031 1000.000000
R22031 MemRRow2031 MemRRow2096 1000.000000
R22096 MemRRow2096 MemRRow2162 1000.000000
R22162 MemRRow2162 MemRRow2229 1000.000000
R22229 MemRRow2229 MemRRow2297 1000.000000
R22297 MemRRow2297 MemRRow2366 1000.000000
R22366 MemRRow2366 MemRRow2436 1000.000000
R22436 MemRRow2436 MemRRow2507 1000.000000
R22507 MemRRow2507 MemRRow2579 1000.000000
R22579 MemRRow2579 MemRRow2652 1000.000000
R22652 MemRRow2652 MemRRow2726 1000.000000
R22726 MemRRow2726 MemRRow2801 1000.000000
R22801 MemRRow2801 MemRRow2877 1000.000000
R22877 MemRRow2877 MemRRow2954 1000.000000
R22954 MemRRow2954 MemRRow3032 1000.000000
R23032 MemRRow3032 MemRRow3111 1000.000000
R23111 MemRRow3111 MemRRow3191 1000.000000
R23191 MemRRow3191 MemRRow3272 1000.000000
R23272 MemRRow3272 MemRRow3354 1000.000000
R23354 MemRRow3354 MemRRow3437 1000.000000
R23437 MemRRow3437 MemRRow3521 1000.000000
R23521 MemRRow3521 MemRRow3606 1000.000000
R23606 MemRRow3606 MemRRow3692 1000.000000
R23692 MemRRow3692 MemRRow3779 1000.000000
R23779 MemRRow3779 MemRRow3867 1000.000000
R23867 MemRRow3867 MemRRow3956 1000.000000
R23956 MemRRow3956 MemRRow4046 1000.000000
R24046 MemRRow4046 MemRRow4137 1000.000000
R24137 MemRRow4137 MemRRow4229 1000.000000
R24229 MemRRow4229 MemRRow4322 1000.000000
R24322 MemRRow4322 MemRRow4416 1000.000000
R24416 MemRRow4416 MemRRow4511 1000.000000
R24511 MemRRow4511 MemRRow4607 1000.000000
R24607 MemRRow4607 MemRRow4704 1000.000000
R24704 MemRRow4704 MemRRow4802 1000.000000
R24802 MemRRow4802 MemRRow4901 1000.000000
R24901 MemRRow4901 MemRRow5001 1000.000000
R21276 MemRRow1276 MemRRow1328 1000.000000
R21328 MemRRow1328 MemRRow1381 1000.000000
R21381 MemRRow1381 MemRRow1435 1000.000000
R21435 MemRRow1435 MemRRow1490 1000.000000
R21490 MemRRow1490 MemRRow1546 1000.000000
R21546 MemRRow1546 MemRRow1603 1000.000000
R21603 MemRRow1603 MemRRow1661 1000.000000
R21661 MemRRow1661 MemRRow1720 1000.000000
R21720 MemRRow1720 MemRRow1780 1000.000000
R21780 MemRRow1780 MemRRow1841 1000.000000
R21841 MemRRow1841 MemRRow1903 1000.000000
R21903 MemRRow1903 MemRRow1966 1000.000000
R21966 MemRRow1966 MemRRow2030 1000.000000
R22030 MemRRow2030 MemRRow2095 1000.000000
R22095 MemRRow2095 MemRRow2161 1000.000000
R22161 MemRRow2161 MemRRow2228 1000.000000
R22228 MemRRow2228 MemRRow2296 1000.000000
R22296 MemRRow2296 MemRRow2365 1000.000000
R22365 MemRRow2365 MemRRow2435 1000.000000
R22435 MemRRow2435 MemRRow2506 1000.000000
R22506 MemRRow2506 MemRRow2578 1000.000000
R22578 MemRRow2578 MemRRow2651 1000.000000
R22651 MemRRow2651 MemRRow2725 1000.000000
R22725 MemRRow2725 MemRRow2800 1000.000000
R22800 MemRRow2800 MemRRow2876 1000.000000
R22876 MemRRow2876 MemRRow2953 1000.000000
R22953 MemRRow2953 MemRRow3031 1000.000000
R23031 MemRRow3031 MemRRow3110 1000.000000
R23110 MemRRow3110 MemRRow3190 1000.000000
R23190 MemRRow3190 MemRRow3271 1000.000000
R23271 MemRRow3271 MemRRow3353 1000.000000
R23353 MemRRow3353 MemRRow3436 1000.000000
R23436 MemRRow3436 MemRRow3520 1000.000000
R23520 MemRRow3520 MemRRow3605 1000.000000
R23605 MemRRow3605 MemRRow3691 1000.000000
R23691 MemRRow3691 MemRRow3778 1000.000000
R23778 MemRRow3778 MemRRow3866 1000.000000
R23866 MemRRow3866 MemRRow3955 1000.000000
R23955 MemRRow3955 MemRRow4045 1000.000000
R24045 MemRRow4045 MemRRow4136 1000.000000
R24136 MemRRow4136 MemRRow4228 1000.000000
R24228 MemRRow4228 MemRRow4321 1000.000000
R24321 MemRRow4321 MemRRow4415 1000.000000
R24415 MemRRow4415 MemRRow4510 1000.000000
R24510 MemRRow4510 MemRRow4606 1000.000000
R24606 MemRRow4606 MemRRow4703 1000.000000
R24703 MemRRow4703 MemRRow4801 1000.000000
R24801 MemRRow4801 MemRRow4900 1000.000000
R24900 MemRRow4900 MemRRow5000 1000.000000
R25000 MemRRow5000 MemRRow5101 1000.000000
R21327 MemRRow1327 MemRRow1380 1000.000000
R21380 MemRRow1380 MemRRow1434 1000.000000
R21434 MemRRow1434 MemRRow1489 1000.000000
R21489 MemRRow1489 MemRRow1545 1000.000000
R21545 MemRRow1545 MemRRow1602 1000.000000
R21602 MemRRow1602 MemRRow1660 1000.000000
R21660 MemRRow1660 MemRRow1719 1000.000000
R21719 MemRRow1719 MemRRow1779 1000.000000
R21779 MemRRow1779 MemRRow1840 1000.000000
R21840 MemRRow1840 MemRRow1902 1000.000000
R21902 MemRRow1902 MemRRow1965 1000.000000
R21965 MemRRow1965 MemRRow2029 1000.000000
R22029 MemRRow2029 MemRRow2094 1000.000000
R22094 MemRRow2094 MemRRow2160 1000.000000
R22160 MemRRow2160 MemRRow2227 1000.000000
R22227 MemRRow2227 MemRRow2295 1000.000000
R22295 MemRRow2295 MemRRow2364 1000.000000
R22364 MemRRow2364 MemRRow2434 1000.000000
R22434 MemRRow2434 MemRRow2505 1000.000000
R22505 MemRRow2505 MemRRow2577 1000.000000
R22577 MemRRow2577 MemRRow2650 1000.000000
R22650 MemRRow2650 MemRRow2724 1000.000000
R22724 MemRRow2724 MemRRow2799 1000.000000
R22799 MemRRow2799 MemRRow2875 1000.000000
R22875 MemRRow2875 MemRRow2952 1000.000000
R22952 MemRRow2952 MemRRow3030 1000.000000
R23030 MemRRow3030 MemRRow3109 1000.000000
R23109 MemRRow3109 MemRRow3189 1000.000000
R23189 MemRRow3189 MemRRow3270 1000.000000
R23270 MemRRow3270 MemRRow3352 1000.000000
R23352 MemRRow3352 MemRRow3435 1000.000000
R23435 MemRRow3435 MemRRow3519 1000.000000
R23519 MemRRow3519 MemRRow3604 1000.000000
R23604 MemRRow3604 MemRRow3690 1000.000000
R23690 MemRRow3690 MemRRow3777 1000.000000
R23777 MemRRow3777 MemRRow3865 1000.000000
R23865 MemRRow3865 MemRRow3954 1000.000000
R23954 MemRRow3954 MemRRow4044 1000.000000
R24044 MemRRow4044 MemRRow4135 1000.000000
R24135 MemRRow4135 MemRRow4227 1000.000000
R24227 MemRRow4227 MemRRow4320 1000.000000
R24320 MemRRow4320 MemRRow4414 1000.000000
R24414 MemRRow4414 MemRRow4509 1000.000000
R24509 MemRRow4509 MemRRow4605 1000.000000
R24605 MemRRow4605 MemRRow4702 1000.000000
R24702 MemRRow4702 MemRRow4800 1000.000000
R24800 MemRRow4800 MemRRow4899 1000.000000
R24899 MemRRow4899 MemRRow4999 1000.000000
R24999 MemRRow4999 MemRRow5100 1000.000000
R25100 MemRRow5100 MemRRow5202 1000.000000

*Line Column Resistances
R34 MemRCol4 MemRCol7 1000.000000
R38 MemRCol8 MemRCol12 1000.000000
R313 MemRCol13 MemRCol18 1000.000000
R319 MemRCol19 MemRCol25 1000.000000
R326 MemRCol26 MemRCol33 1000.000000
R334 MemRCol34 MemRCol42 1000.000000
R343 MemRCol43 MemRCol52 1000.000000
R353 MemRCol53 MemRCol63 1000.000000
R364 MemRCol64 MemRCol75 1000.000000
R376 MemRCol76 MemRCol88 1000.000000
R389 MemRCol89 MemRCol102 1000.000000
R3103 MemRCol103 MemRCol117 1000.000000
R3118 MemRCol118 MemRCol133 1000.000000
R3134 MemRCol134 MemRCol150 1000.000000
R3151 MemRCol151 MemRCol168 1000.000000
R3169 MemRCol169 MemRCol187 1000.000000
R3188 MemRCol188 MemRCol207 1000.000000
R3208 MemRCol208 MemRCol228 1000.000000
R3229 MemRCol229 MemRCol250 1000.000000
R3251 MemRCol251 MemRCol273 1000.000000
R3274 MemRCol274 MemRCol297 1000.000000
R3298 MemRCol298 MemRCol322 1000.000000
R3323 MemRCol323 MemRCol348 1000.000000
R3349 MemRCol349 MemRCol375 1000.000000
R3376 MemRCol376 MemRCol403 1000.000000
R3404 MemRCol404 MemRCol432 1000.000000
R3433 MemRCol433 MemRCol462 1000.000000
R3463 MemRCol463 MemRCol493 1000.000000
R3494 MemRCol494 MemRCol525 1000.000000
R3526 MemRCol526 MemRCol558 1000.000000
R3559 MemRCol559 MemRCol592 1000.000000
R3593 MemRCol593 MemRCol627 1000.000000
R3628 MemRCol628 MemRCol663 1000.000000
R3664 MemRCol664 MemRCol700 1000.000000
R3701 MemRCol701 MemRCol738 1000.000000
R3739 MemRCol739 MemRCol777 1000.000000
R3778 MemRCol778 MemRCol817 1000.000000
R3818 MemRCol818 MemRCol858 1000.000000
R3859 MemRCol859 MemRCol900 1000.000000
R3901 MemRCol901 MemRCol943 1000.000000
R3944 MemRCol944 MemRCol987 1000.000000
R3988 MemRCol988 MemRCol1032 1000.000000
R31033 MemRCol1033 MemRCol1078 1000.000000
R31079 MemRCol1079 MemRCol1125 1000.000000
R31126 MemRCol1126 MemRCol1173 1000.000000
R31174 MemRCol1174 MemRCol1222 1000.000000
R31223 MemRCol1223 MemRCol1272 1000.000000
R31273 MemRCol1273 MemRCol1323 1000.000000
R31324 MemRCol1324 MemRCol1375 1000.000000
R31376 MemRCol1376 MemRCol1428 1000.000000
R37 MemRCol7 MemRCol11 1000.000000
R312 MemRCol12 MemRCol17 1000.000000
R318 MemRCol18 MemRCol24 1000.000000
R325 MemRCol25 MemRCol32 1000.000000
R333 MemRCol33 MemRCol41 1000.000000
R342 MemRCol42 MemRCol51 1000.000000
R352 MemRCol52 MemRCol62 1000.000000
R363 MemRCol63 MemRCol74 1000.000000
R375 MemRCol75 MemRCol87 1000.000000
R388 MemRCol88 MemRCol101 1000.000000
R3102 MemRCol102 MemRCol116 1000.000000
R3117 MemRCol117 MemRCol132 1000.000000
R3133 MemRCol133 MemRCol149 1000.000000
R3150 MemRCol150 MemRCol167 1000.000000
R3168 MemRCol168 MemRCol186 1000.000000
R3187 MemRCol187 MemRCol206 1000.000000
R3207 MemRCol207 MemRCol227 1000.000000
R3228 MemRCol228 MemRCol249 1000.000000
R3250 MemRCol250 MemRCol272 1000.000000
R3273 MemRCol273 MemRCol296 1000.000000
R3297 MemRCol297 MemRCol321 1000.000000
R3322 MemRCol322 MemRCol347 1000.000000
R3348 MemRCol348 MemRCol374 1000.000000
R3375 MemRCol375 MemRCol402 1000.000000
R3403 MemRCol403 MemRCol431 1000.000000
R3432 MemRCol432 MemRCol461 1000.000000
R3462 MemRCol462 MemRCol492 1000.000000
R3493 MemRCol493 MemRCol524 1000.000000
R3525 MemRCol525 MemRCol557 1000.000000
R3558 MemRCol558 MemRCol591 1000.000000
R3592 MemRCol592 MemRCol626 1000.000000
R3627 MemRCol627 MemRCol662 1000.000000
R3663 MemRCol663 MemRCol699 1000.000000
R3700 MemRCol700 MemRCol737 1000.000000
R3738 MemRCol738 MemRCol776 1000.000000
R3777 MemRCol777 MemRCol816 1000.000000
R3817 MemRCol817 MemRCol857 1000.000000
R3858 MemRCol858 MemRCol899 1000.000000
R3900 MemRCol900 MemRCol942 1000.000000
R3943 MemRCol943 MemRCol986 1000.000000
R3987 MemRCol987 MemRCol1031 1000.000000
R31032 MemRCol1032 MemRCol1077 1000.000000
R31078 MemRCol1078 MemRCol1124 1000.000000
R31125 MemRCol1125 MemRCol1172 1000.000000
R31173 MemRCol1173 MemRCol1221 1000.000000
R31222 MemRCol1222 MemRCol1271 1000.000000
R31272 MemRCol1272 MemRCol1322 1000.000000
R31323 MemRCol1323 MemRCol1374 1000.000000
R31375 MemRCol1375 MemRCol1427 1000.000000
R31428 MemRCol1428 MemRCol1481 1000.000000
R311 MemRCol11 MemRCol16 1000.000000
R317 MemRCol17 MemRCol23 1000.000000
R324 MemRCol24 MemRCol31 1000.000000
R332 MemRCol32 MemRCol40 1000.000000
R341 MemRCol41 MemRCol50 1000.000000
R351 MemRCol51 MemRCol61 1000.000000
R362 MemRCol62 MemRCol73 1000.000000
R374 MemRCol74 MemRCol86 1000.000000
R387 MemRCol87 MemRCol100 1000.000000
R3101 MemRCol101 MemRCol115 1000.000000
R3116 MemRCol116 MemRCol131 1000.000000
R3132 MemRCol132 MemRCol148 1000.000000
R3149 MemRCol149 MemRCol166 1000.000000
R3167 MemRCol167 MemRCol185 1000.000000
R3186 MemRCol186 MemRCol205 1000.000000
R3206 MemRCol206 MemRCol226 1000.000000
R3227 MemRCol227 MemRCol248 1000.000000
R3249 MemRCol249 MemRCol271 1000.000000
R3272 MemRCol272 MemRCol295 1000.000000
R3296 MemRCol296 MemRCol320 1000.000000
R3321 MemRCol321 MemRCol346 1000.000000
R3347 MemRCol347 MemRCol373 1000.000000
R3374 MemRCol374 MemRCol401 1000.000000
R3402 MemRCol402 MemRCol430 1000.000000
R3431 MemRCol431 MemRCol460 1000.000000
R3461 MemRCol461 MemRCol491 1000.000000
R3492 MemRCol492 MemRCol523 1000.000000
R3524 MemRCol524 MemRCol556 1000.000000
R3557 MemRCol557 MemRCol590 1000.000000
R3591 MemRCol591 MemRCol625 1000.000000
R3626 MemRCol626 MemRCol661 1000.000000
R3662 MemRCol662 MemRCol698 1000.000000
R3699 MemRCol699 MemRCol736 1000.000000
R3737 MemRCol737 MemRCol775 1000.000000
R3776 MemRCol776 MemRCol815 1000.000000
R3816 MemRCol816 MemRCol856 1000.000000
R3857 MemRCol857 MemRCol898 1000.000000
R3899 MemRCol899 MemRCol941 1000.000000
R3942 MemRCol942 MemRCol985 1000.000000
R3986 MemRCol986 MemRCol1030 1000.000000
R31031 MemRCol1031 MemRCol1076 1000.000000
R31077 MemRCol1077 MemRCol1123 1000.000000
R31124 MemRCol1124 MemRCol1171 1000.000000
R31172 MemRCol1172 MemRCol1220 1000.000000
R31221 MemRCol1221 MemRCol1270 1000.000000
R31271 MemRCol1271 MemRCol1321 1000.000000
R31322 MemRCol1322 MemRCol1373 1000.000000
R31374 MemRCol1374 MemRCol1426 1000.000000
R31427 MemRCol1427 MemRCol1480 1000.000000
R31481 MemRCol1481 MemRCol1535 1000.000000
R316 MemRCol16 MemRCol22 1000.000000
R323 MemRCol23 MemRCol30 1000.000000
R331 MemRCol31 MemRCol39 1000.000000
R340 MemRCol40 MemRCol49 1000.000000
R350 MemRCol50 MemRCol60 1000.000000
R361 MemRCol61 MemRCol72 1000.000000
R373 MemRCol73 MemRCol85 1000.000000
R386 MemRCol86 MemRCol99 1000.000000
R3100 MemRCol100 MemRCol114 1000.000000
R3115 MemRCol115 MemRCol130 1000.000000
R3131 MemRCol131 MemRCol147 1000.000000
R3148 MemRCol148 MemRCol165 1000.000000
R3166 MemRCol166 MemRCol184 1000.000000
R3185 MemRCol185 MemRCol204 1000.000000
R3205 MemRCol205 MemRCol225 1000.000000
R3226 MemRCol226 MemRCol247 1000.000000
R3248 MemRCol248 MemRCol270 1000.000000
R3271 MemRCol271 MemRCol294 1000.000000
R3295 MemRCol295 MemRCol319 1000.000000
R3320 MemRCol320 MemRCol345 1000.000000
R3346 MemRCol346 MemRCol372 1000.000000
R3373 MemRCol373 MemRCol400 1000.000000
R3401 MemRCol401 MemRCol429 1000.000000
R3430 MemRCol430 MemRCol459 1000.000000
R3460 MemRCol460 MemRCol490 1000.000000
R3491 MemRCol491 MemRCol522 1000.000000
R3523 MemRCol523 MemRCol555 1000.000000
R3556 MemRCol556 MemRCol589 1000.000000
R3590 MemRCol590 MemRCol624 1000.000000
R3625 MemRCol625 MemRCol660 1000.000000
R3661 MemRCol661 MemRCol697 1000.000000
R3698 MemRCol698 MemRCol735 1000.000000
R3736 MemRCol736 MemRCol774 1000.000000
R3775 MemRCol775 MemRCol814 1000.000000
R3815 MemRCol815 MemRCol855 1000.000000
R3856 MemRCol856 MemRCol897 1000.000000
R3898 MemRCol898 MemRCol940 1000.000000
R3941 MemRCol941 MemRCol984 1000.000000
R3985 MemRCol985 MemRCol1029 1000.000000
R31030 MemRCol1030 MemRCol1075 1000.000000
R31076 MemRCol1076 MemRCol1122 1000.000000
R31123 MemRCol1123 MemRCol1170 1000.000000
R31171 MemRCol1171 MemRCol1219 1000.000000
R31220 MemRCol1220 MemRCol1269 1000.000000
R31270 MemRCol1270 MemRCol1320 1000.000000
R31321 MemRCol1321 MemRCol1372 1000.000000
R31373 MemRCol1373 MemRCol1425 1000.000000
R31426 MemRCol1426 MemRCol1479 1000.000000
R31480 MemRCol1480 MemRCol1534 1000.000000
R31535 MemRCol1535 MemRCol1590 1000.000000
R322 MemRCol22 MemRCol29 1000.000000
R330 MemRCol30 MemRCol38 1000.000000
R339 MemRCol39 MemRCol48 1000.000000
R349 MemRCol49 MemRCol59 1000.000000
R360 MemRCol60 MemRCol71 1000.000000
R372 MemRCol72 MemRCol84 1000.000000
R385 MemRCol85 MemRCol98 1000.000000
R399 MemRCol99 MemRCol113 1000.000000
R3114 MemRCol114 MemRCol129 1000.000000
R3130 MemRCol130 MemRCol146 1000.000000
R3147 MemRCol147 MemRCol164 1000.000000
R3165 MemRCol165 MemRCol183 1000.000000
R3184 MemRCol184 MemRCol203 1000.000000
R3204 MemRCol204 MemRCol224 1000.000000
R3225 MemRCol225 MemRCol246 1000.000000
R3247 MemRCol247 MemRCol269 1000.000000
R3270 MemRCol270 MemRCol293 1000.000000
R3294 MemRCol294 MemRCol318 1000.000000
R3319 MemRCol319 MemRCol344 1000.000000
R3345 MemRCol345 MemRCol371 1000.000000
R3372 MemRCol372 MemRCol399 1000.000000
R3400 MemRCol400 MemRCol428 1000.000000
R3429 MemRCol429 MemRCol458 1000.000000
R3459 MemRCol459 MemRCol489 1000.000000
R3490 MemRCol490 MemRCol521 1000.000000
R3522 MemRCol522 MemRCol554 1000.000000
R3555 MemRCol555 MemRCol588 1000.000000
R3589 MemRCol589 MemRCol623 1000.000000
R3624 MemRCol624 MemRCol659 1000.000000
R3660 MemRCol660 MemRCol696 1000.000000
R3697 MemRCol697 MemRCol734 1000.000000
R3735 MemRCol735 MemRCol773 1000.000000
R3774 MemRCol774 MemRCol813 1000.000000
R3814 MemRCol814 MemRCol854 1000.000000
R3855 MemRCol855 MemRCol896 1000.000000
R3897 MemRCol897 MemRCol939 1000.000000
R3940 MemRCol940 MemRCol983 1000.000000
R3984 MemRCol984 MemRCol1028 1000.000000
R31029 MemRCol1029 MemRCol1074 1000.000000
R31075 MemRCol1075 MemRCol1121 1000.000000
R31122 MemRCol1122 MemRCol1169 1000.000000
R31170 MemRCol1170 MemRCol1218 1000.000000
R31219 MemRCol1219 MemRCol1268 1000.000000
R31269 MemRCol1269 MemRCol1319 1000.000000
R31320 MemRCol1320 MemRCol1371 1000.000000
R31372 MemRCol1372 MemRCol1424 1000.000000
R31425 MemRCol1425 MemRCol1478 1000.000000
R31479 MemRCol1479 MemRCol1533 1000.000000
R31534 MemRCol1534 MemRCol1589 1000.000000
R31590 MemRCol1590 MemRCol1646 1000.000000
R329 MemRCol29 MemRCol37 1000.000000
R338 MemRCol38 MemRCol47 1000.000000
R348 MemRCol48 MemRCol58 1000.000000
R359 MemRCol59 MemRCol70 1000.000000
R371 MemRCol71 MemRCol83 1000.000000
R384 MemRCol84 MemRCol97 1000.000000
R398 MemRCol98 MemRCol112 1000.000000
R3113 MemRCol113 MemRCol128 1000.000000
R3129 MemRCol129 MemRCol145 1000.000000
R3146 MemRCol146 MemRCol163 1000.000000
R3164 MemRCol164 MemRCol182 1000.000000
R3183 MemRCol183 MemRCol202 1000.000000
R3203 MemRCol203 MemRCol223 1000.000000
R3224 MemRCol224 MemRCol245 1000.000000
R3246 MemRCol246 MemRCol268 1000.000000
R3269 MemRCol269 MemRCol292 1000.000000
R3293 MemRCol293 MemRCol317 1000.000000
R3318 MemRCol318 MemRCol343 1000.000000
R3344 MemRCol344 MemRCol370 1000.000000
R3371 MemRCol371 MemRCol398 1000.000000
R3399 MemRCol399 MemRCol427 1000.000000
R3428 MemRCol428 MemRCol457 1000.000000
R3458 MemRCol458 MemRCol488 1000.000000
R3489 MemRCol489 MemRCol520 1000.000000
R3521 MemRCol521 MemRCol553 1000.000000
R3554 MemRCol554 MemRCol587 1000.000000
R3588 MemRCol588 MemRCol622 1000.000000
R3623 MemRCol623 MemRCol658 1000.000000
R3659 MemRCol659 MemRCol695 1000.000000
R3696 MemRCol696 MemRCol733 1000.000000
R3734 MemRCol734 MemRCol772 1000.000000
R3773 MemRCol773 MemRCol812 1000.000000
R3813 MemRCol813 MemRCol853 1000.000000
R3854 MemRCol854 MemRCol895 1000.000000
R3896 MemRCol896 MemRCol938 1000.000000
R3939 MemRCol939 MemRCol982 1000.000000
R3983 MemRCol983 MemRCol1027 1000.000000
R31028 MemRCol1028 MemRCol1073 1000.000000
R31074 MemRCol1074 MemRCol1120 1000.000000
R31121 MemRCol1121 MemRCol1168 1000.000000
R31169 MemRCol1169 MemRCol1217 1000.000000
R31218 MemRCol1218 MemRCol1267 1000.000000
R31268 MemRCol1268 MemRCol1318 1000.000000
R31319 MemRCol1319 MemRCol1370 1000.000000
R31371 MemRCol1371 MemRCol1423 1000.000000
R31424 MemRCol1424 MemRCol1477 1000.000000
R31478 MemRCol1478 MemRCol1532 1000.000000
R31533 MemRCol1533 MemRCol1588 1000.000000
R31589 MemRCol1589 MemRCol1645 1000.000000
R31646 MemRCol1646 MemRCol1703 1000.000000
R337 MemRCol37 MemRCol46 1000.000000
R347 MemRCol47 MemRCol57 1000.000000
R358 MemRCol58 MemRCol69 1000.000000
R370 MemRCol70 MemRCol82 1000.000000
R383 MemRCol83 MemRCol96 1000.000000
R397 MemRCol97 MemRCol111 1000.000000
R3112 MemRCol112 MemRCol127 1000.000000
R3128 MemRCol128 MemRCol144 1000.000000
R3145 MemRCol145 MemRCol162 1000.000000
R3163 MemRCol163 MemRCol181 1000.000000
R3182 MemRCol182 MemRCol201 1000.000000
R3202 MemRCol202 MemRCol222 1000.000000
R3223 MemRCol223 MemRCol244 1000.000000
R3245 MemRCol245 MemRCol267 1000.000000
R3268 MemRCol268 MemRCol291 1000.000000
R3292 MemRCol292 MemRCol316 1000.000000
R3317 MemRCol317 MemRCol342 1000.000000
R3343 MemRCol343 MemRCol369 1000.000000
R3370 MemRCol370 MemRCol397 1000.000000
R3398 MemRCol398 MemRCol426 1000.000000
R3427 MemRCol427 MemRCol456 1000.000000
R3457 MemRCol457 MemRCol487 1000.000000
R3488 MemRCol488 MemRCol519 1000.000000
R3520 MemRCol520 MemRCol552 1000.000000
R3553 MemRCol553 MemRCol586 1000.000000
R3587 MemRCol587 MemRCol621 1000.000000
R3622 MemRCol622 MemRCol657 1000.000000
R3658 MemRCol658 MemRCol694 1000.000000
R3695 MemRCol695 MemRCol732 1000.000000
R3733 MemRCol733 MemRCol771 1000.000000
R3772 MemRCol772 MemRCol811 1000.000000
R3812 MemRCol812 MemRCol852 1000.000000
R3853 MemRCol853 MemRCol894 1000.000000
R3895 MemRCol895 MemRCol937 1000.000000
R3938 MemRCol938 MemRCol981 1000.000000
R3982 MemRCol982 MemRCol1026 1000.000000
R31027 MemRCol1027 MemRCol1072 1000.000000
R31073 MemRCol1073 MemRCol1119 1000.000000
R31120 MemRCol1120 MemRCol1167 1000.000000
R31168 MemRCol1168 MemRCol1216 1000.000000
R31217 MemRCol1217 MemRCol1266 1000.000000
R31267 MemRCol1267 MemRCol1317 1000.000000
R31318 MemRCol1318 MemRCol1369 1000.000000
R31370 MemRCol1370 MemRCol1422 1000.000000
R31423 MemRCol1423 MemRCol1476 1000.000000
R31477 MemRCol1477 MemRCol1531 1000.000000
R31532 MemRCol1532 MemRCol1587 1000.000000
R31588 MemRCol1588 MemRCol1644 1000.000000
R31645 MemRCol1645 MemRCol1702 1000.000000
R31703 MemRCol1703 MemRCol1761 1000.000000
R346 MemRCol46 MemRCol56 1000.000000
R357 MemRCol57 MemRCol68 1000.000000
R369 MemRCol69 MemRCol81 1000.000000
R382 MemRCol82 MemRCol95 1000.000000
R396 MemRCol96 MemRCol110 1000.000000
R3111 MemRCol111 MemRCol126 1000.000000
R3127 MemRCol127 MemRCol143 1000.000000
R3144 MemRCol144 MemRCol161 1000.000000
R3162 MemRCol162 MemRCol180 1000.000000
R3181 MemRCol181 MemRCol200 1000.000000
R3201 MemRCol201 MemRCol221 1000.000000
R3222 MemRCol222 MemRCol243 1000.000000
R3244 MemRCol244 MemRCol266 1000.000000
R3267 MemRCol267 MemRCol290 1000.000000
R3291 MemRCol291 MemRCol315 1000.000000
R3316 MemRCol316 MemRCol341 1000.000000
R3342 MemRCol342 MemRCol368 1000.000000
R3369 MemRCol369 MemRCol396 1000.000000
R3397 MemRCol397 MemRCol425 1000.000000
R3426 MemRCol426 MemRCol455 1000.000000
R3456 MemRCol456 MemRCol486 1000.000000
R3487 MemRCol487 MemRCol518 1000.000000
R3519 MemRCol519 MemRCol551 1000.000000
R3552 MemRCol552 MemRCol585 1000.000000
R3586 MemRCol586 MemRCol620 1000.000000
R3621 MemRCol621 MemRCol656 1000.000000
R3657 MemRCol657 MemRCol693 1000.000000
R3694 MemRCol694 MemRCol731 1000.000000
R3732 MemRCol732 MemRCol770 1000.000000
R3771 MemRCol771 MemRCol810 1000.000000
R3811 MemRCol811 MemRCol851 1000.000000
R3852 MemRCol852 MemRCol893 1000.000000
R3894 MemRCol894 MemRCol936 1000.000000
R3937 MemRCol937 MemRCol980 1000.000000
R3981 MemRCol981 MemRCol1025 1000.000000
R31026 MemRCol1026 MemRCol1071 1000.000000
R31072 MemRCol1072 MemRCol1118 1000.000000
R31119 MemRCol1119 MemRCol1166 1000.000000
R31167 MemRCol1167 MemRCol1215 1000.000000
R31216 MemRCol1216 MemRCol1265 1000.000000
R31266 MemRCol1266 MemRCol1316 1000.000000
R31317 MemRCol1317 MemRCol1368 1000.000000
R31369 MemRCol1369 MemRCol1421 1000.000000
R31422 MemRCol1422 MemRCol1475 1000.000000
R31476 MemRCol1476 MemRCol1530 1000.000000
R31531 MemRCol1531 MemRCol1586 1000.000000
R31587 MemRCol1587 MemRCol1643 1000.000000
R31644 MemRCol1644 MemRCol1701 1000.000000
R31702 MemRCol1702 MemRCol1760 1000.000000
R31761 MemRCol1761 MemRCol1820 1000.000000
R356 MemRCol56 MemRCol67 1000.000000
R368 MemRCol68 MemRCol80 1000.000000
R381 MemRCol81 MemRCol94 1000.000000
R395 MemRCol95 MemRCol109 1000.000000
R3110 MemRCol110 MemRCol125 1000.000000
R3126 MemRCol126 MemRCol142 1000.000000
R3143 MemRCol143 MemRCol160 1000.000000
R3161 MemRCol161 MemRCol179 1000.000000
R3180 MemRCol180 MemRCol199 1000.000000
R3200 MemRCol200 MemRCol220 1000.000000
R3221 MemRCol221 MemRCol242 1000.000000
R3243 MemRCol243 MemRCol265 1000.000000
R3266 MemRCol266 MemRCol289 1000.000000
R3290 MemRCol290 MemRCol314 1000.000000
R3315 MemRCol315 MemRCol340 1000.000000
R3341 MemRCol341 MemRCol367 1000.000000
R3368 MemRCol368 MemRCol395 1000.000000
R3396 MemRCol396 MemRCol424 1000.000000
R3425 MemRCol425 MemRCol454 1000.000000
R3455 MemRCol455 MemRCol485 1000.000000
R3486 MemRCol486 MemRCol517 1000.000000
R3518 MemRCol518 MemRCol550 1000.000000
R3551 MemRCol551 MemRCol584 1000.000000
R3585 MemRCol585 MemRCol619 1000.000000
R3620 MemRCol620 MemRCol655 1000.000000
R3656 MemRCol656 MemRCol692 1000.000000
R3693 MemRCol693 MemRCol730 1000.000000
R3731 MemRCol731 MemRCol769 1000.000000
R3770 MemRCol770 MemRCol809 1000.000000
R3810 MemRCol810 MemRCol850 1000.000000
R3851 MemRCol851 MemRCol892 1000.000000
R3893 MemRCol893 MemRCol935 1000.000000
R3936 MemRCol936 MemRCol979 1000.000000
R3980 MemRCol980 MemRCol1024 1000.000000
R31025 MemRCol1025 MemRCol1070 1000.000000
R31071 MemRCol1071 MemRCol1117 1000.000000
R31118 MemRCol1118 MemRCol1165 1000.000000
R31166 MemRCol1166 MemRCol1214 1000.000000
R31215 MemRCol1215 MemRCol1264 1000.000000
R31265 MemRCol1265 MemRCol1315 1000.000000
R31316 MemRCol1316 MemRCol1367 1000.000000
R31368 MemRCol1368 MemRCol1420 1000.000000
R31421 MemRCol1421 MemRCol1474 1000.000000
R31475 MemRCol1475 MemRCol1529 1000.000000
R31530 MemRCol1530 MemRCol1585 1000.000000
R31586 MemRCol1586 MemRCol1642 1000.000000
R31643 MemRCol1643 MemRCol1700 1000.000000
R31701 MemRCol1701 MemRCol1759 1000.000000
R31760 MemRCol1760 MemRCol1819 1000.000000
R31820 MemRCol1820 MemRCol1880 1000.000000
R367 MemRCol67 MemRCol79 1000.000000
R380 MemRCol80 MemRCol93 1000.000000
R394 MemRCol94 MemRCol108 1000.000000
R3109 MemRCol109 MemRCol124 1000.000000
R3125 MemRCol125 MemRCol141 1000.000000
R3142 MemRCol142 MemRCol159 1000.000000
R3160 MemRCol160 MemRCol178 1000.000000
R3179 MemRCol179 MemRCol198 1000.000000
R3199 MemRCol199 MemRCol219 1000.000000
R3220 MemRCol220 MemRCol241 1000.000000
R3242 MemRCol242 MemRCol264 1000.000000
R3265 MemRCol265 MemRCol288 1000.000000
R3289 MemRCol289 MemRCol313 1000.000000
R3314 MemRCol314 MemRCol339 1000.000000
R3340 MemRCol340 MemRCol366 1000.000000
R3367 MemRCol367 MemRCol394 1000.000000
R3395 MemRCol395 MemRCol423 1000.000000
R3424 MemRCol424 MemRCol453 1000.000000
R3454 MemRCol454 MemRCol484 1000.000000
R3485 MemRCol485 MemRCol516 1000.000000
R3517 MemRCol517 MemRCol549 1000.000000
R3550 MemRCol550 MemRCol583 1000.000000
R3584 MemRCol584 MemRCol618 1000.000000
R3619 MemRCol619 MemRCol654 1000.000000
R3655 MemRCol655 MemRCol691 1000.000000
R3692 MemRCol692 MemRCol729 1000.000000
R3730 MemRCol730 MemRCol768 1000.000000
R3769 MemRCol769 MemRCol808 1000.000000
R3809 MemRCol809 MemRCol849 1000.000000
R3850 MemRCol850 MemRCol891 1000.000000
R3892 MemRCol892 MemRCol934 1000.000000
R3935 MemRCol935 MemRCol978 1000.000000
R3979 MemRCol979 MemRCol1023 1000.000000
R31024 MemRCol1024 MemRCol1069 1000.000000
R31070 MemRCol1070 MemRCol1116 1000.000000
R31117 MemRCol1117 MemRCol1164 1000.000000
R31165 MemRCol1165 MemRCol1213 1000.000000
R31214 MemRCol1214 MemRCol1263 1000.000000
R31264 MemRCol1264 MemRCol1314 1000.000000
R31315 MemRCol1315 MemRCol1366 1000.000000
R31367 MemRCol1367 MemRCol1419 1000.000000
R31420 MemRCol1420 MemRCol1473 1000.000000
R31474 MemRCol1474 MemRCol1528 1000.000000
R31529 MemRCol1529 MemRCol1584 1000.000000
R31585 MemRCol1585 MemRCol1641 1000.000000
R31642 MemRCol1642 MemRCol1699 1000.000000
R31700 MemRCol1700 MemRCol1758 1000.000000
R31759 MemRCol1759 MemRCol1818 1000.000000
R31819 MemRCol1819 MemRCol1879 1000.000000
R31880 MemRCol1880 MemRCol1941 1000.000000
R379 MemRCol79 MemRCol92 1000.000000
R393 MemRCol93 MemRCol107 1000.000000
R3108 MemRCol108 MemRCol123 1000.000000
R3124 MemRCol124 MemRCol140 1000.000000
R3141 MemRCol141 MemRCol158 1000.000000
R3159 MemRCol159 MemRCol177 1000.000000
R3178 MemRCol178 MemRCol197 1000.000000
R3198 MemRCol198 MemRCol218 1000.000000
R3219 MemRCol219 MemRCol240 1000.000000
R3241 MemRCol241 MemRCol263 1000.000000
R3264 MemRCol264 MemRCol287 1000.000000
R3288 MemRCol288 MemRCol312 1000.000000
R3313 MemRCol313 MemRCol338 1000.000000
R3339 MemRCol339 MemRCol365 1000.000000
R3366 MemRCol366 MemRCol393 1000.000000
R3394 MemRCol394 MemRCol422 1000.000000
R3423 MemRCol423 MemRCol452 1000.000000
R3453 MemRCol453 MemRCol483 1000.000000
R3484 MemRCol484 MemRCol515 1000.000000
R3516 MemRCol516 MemRCol548 1000.000000
R3549 MemRCol549 MemRCol582 1000.000000
R3583 MemRCol583 MemRCol617 1000.000000
R3618 MemRCol618 MemRCol653 1000.000000
R3654 MemRCol654 MemRCol690 1000.000000
R3691 MemRCol691 MemRCol728 1000.000000
R3729 MemRCol729 MemRCol767 1000.000000
R3768 MemRCol768 MemRCol807 1000.000000
R3808 MemRCol808 MemRCol848 1000.000000
R3849 MemRCol849 MemRCol890 1000.000000
R3891 MemRCol891 MemRCol933 1000.000000
R3934 MemRCol934 MemRCol977 1000.000000
R3978 MemRCol978 MemRCol1022 1000.000000
R31023 MemRCol1023 MemRCol1068 1000.000000
R31069 MemRCol1069 MemRCol1115 1000.000000
R31116 MemRCol1116 MemRCol1163 1000.000000
R31164 MemRCol1164 MemRCol1212 1000.000000
R31213 MemRCol1213 MemRCol1262 1000.000000
R31263 MemRCol1263 MemRCol1313 1000.000000
R31314 MemRCol1314 MemRCol1365 1000.000000
R31366 MemRCol1366 MemRCol1418 1000.000000
R31419 MemRCol1419 MemRCol1472 1000.000000
R31473 MemRCol1473 MemRCol1527 1000.000000
R31528 MemRCol1528 MemRCol1583 1000.000000
R31584 MemRCol1584 MemRCol1640 1000.000000
R31641 MemRCol1641 MemRCol1698 1000.000000
R31699 MemRCol1699 MemRCol1757 1000.000000
R31758 MemRCol1758 MemRCol1817 1000.000000
R31818 MemRCol1818 MemRCol1878 1000.000000
R31879 MemRCol1879 MemRCol1940 1000.000000
R31941 MemRCol1941 MemRCol2003 1000.000000
R392 MemRCol92 MemRCol106 1000.000000
R3107 MemRCol107 MemRCol122 1000.000000
R3123 MemRCol123 MemRCol139 1000.000000
R3140 MemRCol140 MemRCol157 1000.000000
R3158 MemRCol158 MemRCol176 1000.000000
R3177 MemRCol177 MemRCol196 1000.000000
R3197 MemRCol197 MemRCol217 1000.000000
R3218 MemRCol218 MemRCol239 1000.000000
R3240 MemRCol240 MemRCol262 1000.000000
R3263 MemRCol263 MemRCol286 1000.000000
R3287 MemRCol287 MemRCol311 1000.000000
R3312 MemRCol312 MemRCol337 1000.000000
R3338 MemRCol338 MemRCol364 1000.000000
R3365 MemRCol365 MemRCol392 1000.000000
R3393 MemRCol393 MemRCol421 1000.000000
R3422 MemRCol422 MemRCol451 1000.000000
R3452 MemRCol452 MemRCol482 1000.000000
R3483 MemRCol483 MemRCol514 1000.000000
R3515 MemRCol515 MemRCol547 1000.000000
R3548 MemRCol548 MemRCol581 1000.000000
R3582 MemRCol582 MemRCol616 1000.000000
R3617 MemRCol617 MemRCol652 1000.000000
R3653 MemRCol653 MemRCol689 1000.000000
R3690 MemRCol690 MemRCol727 1000.000000
R3728 MemRCol728 MemRCol766 1000.000000
R3767 MemRCol767 MemRCol806 1000.000000
R3807 MemRCol807 MemRCol847 1000.000000
R3848 MemRCol848 MemRCol889 1000.000000
R3890 MemRCol890 MemRCol932 1000.000000
R3933 MemRCol933 MemRCol976 1000.000000
R3977 MemRCol977 MemRCol1021 1000.000000
R31022 MemRCol1022 MemRCol1067 1000.000000
R31068 MemRCol1068 MemRCol1114 1000.000000
R31115 MemRCol1115 MemRCol1162 1000.000000
R31163 MemRCol1163 MemRCol1211 1000.000000
R31212 MemRCol1212 MemRCol1261 1000.000000
R31262 MemRCol1262 MemRCol1312 1000.000000
R31313 MemRCol1313 MemRCol1364 1000.000000
R31365 MemRCol1365 MemRCol1417 1000.000000
R31418 MemRCol1418 MemRCol1471 1000.000000
R31472 MemRCol1472 MemRCol1526 1000.000000
R31527 MemRCol1527 MemRCol1582 1000.000000
R31583 MemRCol1583 MemRCol1639 1000.000000
R31640 MemRCol1640 MemRCol1697 1000.000000
R31698 MemRCol1698 MemRCol1756 1000.000000
R31757 MemRCol1757 MemRCol1816 1000.000000
R31817 MemRCol1817 MemRCol1877 1000.000000
R31878 MemRCol1878 MemRCol1939 1000.000000
R31940 MemRCol1940 MemRCol2002 1000.000000
R32003 MemRCol2003 MemRCol2066 1000.000000
R3106 MemRCol106 MemRCol121 1000.000000
R3122 MemRCol122 MemRCol138 1000.000000
R3139 MemRCol139 MemRCol156 1000.000000
R3157 MemRCol157 MemRCol175 1000.000000
R3176 MemRCol176 MemRCol195 1000.000000
R3196 MemRCol196 MemRCol216 1000.000000
R3217 MemRCol217 MemRCol238 1000.000000
R3239 MemRCol239 MemRCol261 1000.000000
R3262 MemRCol262 MemRCol285 1000.000000
R3286 MemRCol286 MemRCol310 1000.000000
R3311 MemRCol311 MemRCol336 1000.000000
R3337 MemRCol337 MemRCol363 1000.000000
R3364 MemRCol364 MemRCol391 1000.000000
R3392 MemRCol392 MemRCol420 1000.000000
R3421 MemRCol421 MemRCol450 1000.000000
R3451 MemRCol451 MemRCol481 1000.000000
R3482 MemRCol482 MemRCol513 1000.000000
R3514 MemRCol514 MemRCol546 1000.000000
R3547 MemRCol547 MemRCol580 1000.000000
R3581 MemRCol581 MemRCol615 1000.000000
R3616 MemRCol616 MemRCol651 1000.000000
R3652 MemRCol652 MemRCol688 1000.000000
R3689 MemRCol689 MemRCol726 1000.000000
R3727 MemRCol727 MemRCol765 1000.000000
R3766 MemRCol766 MemRCol805 1000.000000
R3806 MemRCol806 MemRCol846 1000.000000
R3847 MemRCol847 MemRCol888 1000.000000
R3889 MemRCol889 MemRCol931 1000.000000
R3932 MemRCol932 MemRCol975 1000.000000
R3976 MemRCol976 MemRCol1020 1000.000000
R31021 MemRCol1021 MemRCol1066 1000.000000
R31067 MemRCol1067 MemRCol1113 1000.000000
R31114 MemRCol1114 MemRCol1161 1000.000000
R31162 MemRCol1162 MemRCol1210 1000.000000
R31211 MemRCol1211 MemRCol1260 1000.000000
R31261 MemRCol1261 MemRCol1311 1000.000000
R31312 MemRCol1312 MemRCol1363 1000.000000
R31364 MemRCol1364 MemRCol1416 1000.000000
R31417 MemRCol1417 MemRCol1470 1000.000000
R31471 MemRCol1471 MemRCol1525 1000.000000
R31526 MemRCol1526 MemRCol1581 1000.000000
R31582 MemRCol1582 MemRCol1638 1000.000000
R31639 MemRCol1639 MemRCol1696 1000.000000
R31697 MemRCol1697 MemRCol1755 1000.000000
R31756 MemRCol1756 MemRCol1815 1000.000000
R31816 MemRCol1816 MemRCol1876 1000.000000
R31877 MemRCol1877 MemRCol1938 1000.000000
R31939 MemRCol1939 MemRCol2001 1000.000000
R32002 MemRCol2002 MemRCol2065 1000.000000
R32066 MemRCol2066 MemRCol2130 1000.000000
R3121 MemRCol121 MemRCol137 1000.000000
R3138 MemRCol138 MemRCol155 1000.000000
R3156 MemRCol156 MemRCol174 1000.000000
R3175 MemRCol175 MemRCol194 1000.000000
R3195 MemRCol195 MemRCol215 1000.000000
R3216 MemRCol216 MemRCol237 1000.000000
R3238 MemRCol238 MemRCol260 1000.000000
R3261 MemRCol261 MemRCol284 1000.000000
R3285 MemRCol285 MemRCol309 1000.000000
R3310 MemRCol310 MemRCol335 1000.000000
R3336 MemRCol336 MemRCol362 1000.000000
R3363 MemRCol363 MemRCol390 1000.000000
R3391 MemRCol391 MemRCol419 1000.000000
R3420 MemRCol420 MemRCol449 1000.000000
R3450 MemRCol450 MemRCol480 1000.000000
R3481 MemRCol481 MemRCol512 1000.000000
R3513 MemRCol513 MemRCol545 1000.000000
R3546 MemRCol546 MemRCol579 1000.000000
R3580 MemRCol580 MemRCol614 1000.000000
R3615 MemRCol615 MemRCol650 1000.000000
R3651 MemRCol651 MemRCol687 1000.000000
R3688 MemRCol688 MemRCol725 1000.000000
R3726 MemRCol726 MemRCol764 1000.000000
R3765 MemRCol765 MemRCol804 1000.000000
R3805 MemRCol805 MemRCol845 1000.000000
R3846 MemRCol846 MemRCol887 1000.000000
R3888 MemRCol888 MemRCol930 1000.000000
R3931 MemRCol931 MemRCol974 1000.000000
R3975 MemRCol975 MemRCol1019 1000.000000
R31020 MemRCol1020 MemRCol1065 1000.000000
R31066 MemRCol1066 MemRCol1112 1000.000000
R31113 MemRCol1113 MemRCol1160 1000.000000
R31161 MemRCol1161 MemRCol1209 1000.000000
R31210 MemRCol1210 MemRCol1259 1000.000000
R31260 MemRCol1260 MemRCol1310 1000.000000
R31311 MemRCol1311 MemRCol1362 1000.000000
R31363 MemRCol1363 MemRCol1415 1000.000000
R31416 MemRCol1416 MemRCol1469 1000.000000
R31470 MemRCol1470 MemRCol1524 1000.000000
R31525 MemRCol1525 MemRCol1580 1000.000000
R31581 MemRCol1581 MemRCol1637 1000.000000
R31638 MemRCol1638 MemRCol1695 1000.000000
R31696 MemRCol1696 MemRCol1754 1000.000000
R31755 MemRCol1755 MemRCol1814 1000.000000
R31815 MemRCol1815 MemRCol1875 1000.000000
R31876 MemRCol1876 MemRCol1937 1000.000000
R31938 MemRCol1938 MemRCol2000 1000.000000
R32001 MemRCol2001 MemRCol2064 1000.000000
R32065 MemRCol2065 MemRCol2129 1000.000000
R32130 MemRCol2130 MemRCol2195 1000.000000
R3137 MemRCol137 MemRCol154 1000.000000
R3155 MemRCol155 MemRCol173 1000.000000
R3174 MemRCol174 MemRCol193 1000.000000
R3194 MemRCol194 MemRCol214 1000.000000
R3215 MemRCol215 MemRCol236 1000.000000
R3237 MemRCol237 MemRCol259 1000.000000
R3260 MemRCol260 MemRCol283 1000.000000
R3284 MemRCol284 MemRCol308 1000.000000
R3309 MemRCol309 MemRCol334 1000.000000
R3335 MemRCol335 MemRCol361 1000.000000
R3362 MemRCol362 MemRCol389 1000.000000
R3390 MemRCol390 MemRCol418 1000.000000
R3419 MemRCol419 MemRCol448 1000.000000
R3449 MemRCol449 MemRCol479 1000.000000
R3480 MemRCol480 MemRCol511 1000.000000
R3512 MemRCol512 MemRCol544 1000.000000
R3545 MemRCol545 MemRCol578 1000.000000
R3579 MemRCol579 MemRCol613 1000.000000
R3614 MemRCol614 MemRCol649 1000.000000
R3650 MemRCol650 MemRCol686 1000.000000
R3687 MemRCol687 MemRCol724 1000.000000
R3725 MemRCol725 MemRCol763 1000.000000
R3764 MemRCol764 MemRCol803 1000.000000
R3804 MemRCol804 MemRCol844 1000.000000
R3845 MemRCol845 MemRCol886 1000.000000
R3887 MemRCol887 MemRCol929 1000.000000
R3930 MemRCol930 MemRCol973 1000.000000
R3974 MemRCol974 MemRCol1018 1000.000000
R31019 MemRCol1019 MemRCol1064 1000.000000
R31065 MemRCol1065 MemRCol1111 1000.000000
R31112 MemRCol1112 MemRCol1159 1000.000000
R31160 MemRCol1160 MemRCol1208 1000.000000
R31209 MemRCol1209 MemRCol1258 1000.000000
R31259 MemRCol1259 MemRCol1309 1000.000000
R31310 MemRCol1310 MemRCol1361 1000.000000
R31362 MemRCol1362 MemRCol1414 1000.000000
R31415 MemRCol1415 MemRCol1468 1000.000000
R31469 MemRCol1469 MemRCol1523 1000.000000
R31524 MemRCol1524 MemRCol1579 1000.000000
R31580 MemRCol1580 MemRCol1636 1000.000000
R31637 MemRCol1637 MemRCol1694 1000.000000
R31695 MemRCol1695 MemRCol1753 1000.000000
R31754 MemRCol1754 MemRCol1813 1000.000000
R31814 MemRCol1814 MemRCol1874 1000.000000
R31875 MemRCol1875 MemRCol1936 1000.000000
R31937 MemRCol1937 MemRCol1999 1000.000000
R32000 MemRCol2000 MemRCol2063 1000.000000
R32064 MemRCol2064 MemRCol2128 1000.000000
R32129 MemRCol2129 MemRCol2194 1000.000000
R32195 MemRCol2195 MemRCol2261 1000.000000
R3154 MemRCol154 MemRCol172 1000.000000
R3173 MemRCol173 MemRCol192 1000.000000
R3193 MemRCol193 MemRCol213 1000.000000
R3214 MemRCol214 MemRCol235 1000.000000
R3236 MemRCol236 MemRCol258 1000.000000
R3259 MemRCol259 MemRCol282 1000.000000
R3283 MemRCol283 MemRCol307 1000.000000
R3308 MemRCol308 MemRCol333 1000.000000
R3334 MemRCol334 MemRCol360 1000.000000
R3361 MemRCol361 MemRCol388 1000.000000
R3389 MemRCol389 MemRCol417 1000.000000
R3418 MemRCol418 MemRCol447 1000.000000
R3448 MemRCol448 MemRCol478 1000.000000
R3479 MemRCol479 MemRCol510 1000.000000
R3511 MemRCol511 MemRCol543 1000.000000
R3544 MemRCol544 MemRCol577 1000.000000
R3578 MemRCol578 MemRCol612 1000.000000
R3613 MemRCol613 MemRCol648 1000.000000
R3649 MemRCol649 MemRCol685 1000.000000
R3686 MemRCol686 MemRCol723 1000.000000
R3724 MemRCol724 MemRCol762 1000.000000
R3763 MemRCol763 MemRCol802 1000.000000
R3803 MemRCol803 MemRCol843 1000.000000
R3844 MemRCol844 MemRCol885 1000.000000
R3886 MemRCol886 MemRCol928 1000.000000
R3929 MemRCol929 MemRCol972 1000.000000
R3973 MemRCol973 MemRCol1017 1000.000000
R31018 MemRCol1018 MemRCol1063 1000.000000
R31064 MemRCol1064 MemRCol1110 1000.000000
R31111 MemRCol1111 MemRCol1158 1000.000000
R31159 MemRCol1159 MemRCol1207 1000.000000
R31208 MemRCol1208 MemRCol1257 1000.000000
R31258 MemRCol1258 MemRCol1308 1000.000000
R31309 MemRCol1309 MemRCol1360 1000.000000
R31361 MemRCol1361 MemRCol1413 1000.000000
R31414 MemRCol1414 MemRCol1467 1000.000000
R31468 MemRCol1468 MemRCol1522 1000.000000
R31523 MemRCol1523 MemRCol1578 1000.000000
R31579 MemRCol1579 MemRCol1635 1000.000000
R31636 MemRCol1636 MemRCol1693 1000.000000
R31694 MemRCol1694 MemRCol1752 1000.000000
R31753 MemRCol1753 MemRCol1812 1000.000000
R31813 MemRCol1813 MemRCol1873 1000.000000
R31874 MemRCol1874 MemRCol1935 1000.000000
R31936 MemRCol1936 MemRCol1998 1000.000000
R31999 MemRCol1999 MemRCol2062 1000.000000
R32063 MemRCol2063 MemRCol2127 1000.000000
R32128 MemRCol2128 MemRCol2193 1000.000000
R32194 MemRCol2194 MemRCol2260 1000.000000
R32261 MemRCol2261 MemRCol2328 1000.000000
R3172 MemRCol172 MemRCol191 1000.000000
R3192 MemRCol192 MemRCol212 1000.000000
R3213 MemRCol213 MemRCol234 1000.000000
R3235 MemRCol235 MemRCol257 1000.000000
R3258 MemRCol258 MemRCol281 1000.000000
R3282 MemRCol282 MemRCol306 1000.000000
R3307 MemRCol307 MemRCol332 1000.000000
R3333 MemRCol333 MemRCol359 1000.000000
R3360 MemRCol360 MemRCol387 1000.000000
R3388 MemRCol388 MemRCol416 1000.000000
R3417 MemRCol417 MemRCol446 1000.000000
R3447 MemRCol447 MemRCol477 1000.000000
R3478 MemRCol478 MemRCol509 1000.000000
R3510 MemRCol510 MemRCol542 1000.000000
R3543 MemRCol543 MemRCol576 1000.000000
R3577 MemRCol577 MemRCol611 1000.000000
R3612 MemRCol612 MemRCol647 1000.000000
R3648 MemRCol648 MemRCol684 1000.000000
R3685 MemRCol685 MemRCol722 1000.000000
R3723 MemRCol723 MemRCol761 1000.000000
R3762 MemRCol762 MemRCol801 1000.000000
R3802 MemRCol802 MemRCol842 1000.000000
R3843 MemRCol843 MemRCol884 1000.000000
R3885 MemRCol885 MemRCol927 1000.000000
R3928 MemRCol928 MemRCol971 1000.000000
R3972 MemRCol972 MemRCol1016 1000.000000
R31017 MemRCol1017 MemRCol1062 1000.000000
R31063 MemRCol1063 MemRCol1109 1000.000000
R31110 MemRCol1110 MemRCol1157 1000.000000
R31158 MemRCol1158 MemRCol1206 1000.000000
R31207 MemRCol1207 MemRCol1256 1000.000000
R31257 MemRCol1257 MemRCol1307 1000.000000
R31308 MemRCol1308 MemRCol1359 1000.000000
R31360 MemRCol1360 MemRCol1412 1000.000000
R31413 MemRCol1413 MemRCol1466 1000.000000
R31467 MemRCol1467 MemRCol1521 1000.000000
R31522 MemRCol1522 MemRCol1577 1000.000000
R31578 MemRCol1578 MemRCol1634 1000.000000
R31635 MemRCol1635 MemRCol1692 1000.000000
R31693 MemRCol1693 MemRCol1751 1000.000000
R31752 MemRCol1752 MemRCol1811 1000.000000
R31812 MemRCol1812 MemRCol1872 1000.000000
R31873 MemRCol1873 MemRCol1934 1000.000000
R31935 MemRCol1935 MemRCol1997 1000.000000
R31998 MemRCol1998 MemRCol2061 1000.000000
R32062 MemRCol2062 MemRCol2126 1000.000000
R32127 MemRCol2127 MemRCol2192 1000.000000
R32193 MemRCol2193 MemRCol2259 1000.000000
R32260 MemRCol2260 MemRCol2327 1000.000000
R32328 MemRCol2328 MemRCol2396 1000.000000
R3191 MemRCol191 MemRCol211 1000.000000
R3212 MemRCol212 MemRCol233 1000.000000
R3234 MemRCol234 MemRCol256 1000.000000
R3257 MemRCol257 MemRCol280 1000.000000
R3281 MemRCol281 MemRCol305 1000.000000
R3306 MemRCol306 MemRCol331 1000.000000
R3332 MemRCol332 MemRCol358 1000.000000
R3359 MemRCol359 MemRCol386 1000.000000
R3387 MemRCol387 MemRCol415 1000.000000
R3416 MemRCol416 MemRCol445 1000.000000
R3446 MemRCol446 MemRCol476 1000.000000
R3477 MemRCol477 MemRCol508 1000.000000
R3509 MemRCol509 MemRCol541 1000.000000
R3542 MemRCol542 MemRCol575 1000.000000
R3576 MemRCol576 MemRCol610 1000.000000
R3611 MemRCol611 MemRCol646 1000.000000
R3647 MemRCol647 MemRCol683 1000.000000
R3684 MemRCol684 MemRCol721 1000.000000
R3722 MemRCol722 MemRCol760 1000.000000
R3761 MemRCol761 MemRCol800 1000.000000
R3801 MemRCol801 MemRCol841 1000.000000
R3842 MemRCol842 MemRCol883 1000.000000
R3884 MemRCol884 MemRCol926 1000.000000
R3927 MemRCol927 MemRCol970 1000.000000
R3971 MemRCol971 MemRCol1015 1000.000000
R31016 MemRCol1016 MemRCol1061 1000.000000
R31062 MemRCol1062 MemRCol1108 1000.000000
R31109 MemRCol1109 MemRCol1156 1000.000000
R31157 MemRCol1157 MemRCol1205 1000.000000
R31206 MemRCol1206 MemRCol1255 1000.000000
R31256 MemRCol1256 MemRCol1306 1000.000000
R31307 MemRCol1307 MemRCol1358 1000.000000
R31359 MemRCol1359 MemRCol1411 1000.000000
R31412 MemRCol1412 MemRCol1465 1000.000000
R31466 MemRCol1466 MemRCol1520 1000.000000
R31521 MemRCol1521 MemRCol1576 1000.000000
R31577 MemRCol1577 MemRCol1633 1000.000000
R31634 MemRCol1634 MemRCol1691 1000.000000
R31692 MemRCol1692 MemRCol1750 1000.000000
R31751 MemRCol1751 MemRCol1810 1000.000000
R31811 MemRCol1811 MemRCol1871 1000.000000
R31872 MemRCol1872 MemRCol1933 1000.000000
R31934 MemRCol1934 MemRCol1996 1000.000000
R31997 MemRCol1997 MemRCol2060 1000.000000
R32061 MemRCol2061 MemRCol2125 1000.000000
R32126 MemRCol2126 MemRCol2191 1000.000000
R32192 MemRCol2192 MemRCol2258 1000.000000
R32259 MemRCol2259 MemRCol2326 1000.000000
R32327 MemRCol2327 MemRCol2395 1000.000000
R32396 MemRCol2396 MemRCol2465 1000.000000
R3211 MemRCol211 MemRCol232 1000.000000
R3233 MemRCol233 MemRCol255 1000.000000
R3256 MemRCol256 MemRCol279 1000.000000
R3280 MemRCol280 MemRCol304 1000.000000
R3305 MemRCol305 MemRCol330 1000.000000
R3331 MemRCol331 MemRCol357 1000.000000
R3358 MemRCol358 MemRCol385 1000.000000
R3386 MemRCol386 MemRCol414 1000.000000
R3415 MemRCol415 MemRCol444 1000.000000
R3445 MemRCol445 MemRCol475 1000.000000
R3476 MemRCol476 MemRCol507 1000.000000
R3508 MemRCol508 MemRCol540 1000.000000
R3541 MemRCol541 MemRCol574 1000.000000
R3575 MemRCol575 MemRCol609 1000.000000
R3610 MemRCol610 MemRCol645 1000.000000
R3646 MemRCol646 MemRCol682 1000.000000
R3683 MemRCol683 MemRCol720 1000.000000
R3721 MemRCol721 MemRCol759 1000.000000
R3760 MemRCol760 MemRCol799 1000.000000
R3800 MemRCol800 MemRCol840 1000.000000
R3841 MemRCol841 MemRCol882 1000.000000
R3883 MemRCol883 MemRCol925 1000.000000
R3926 MemRCol926 MemRCol969 1000.000000
R3970 MemRCol970 MemRCol1014 1000.000000
R31015 MemRCol1015 MemRCol1060 1000.000000
R31061 MemRCol1061 MemRCol1107 1000.000000
R31108 MemRCol1108 MemRCol1155 1000.000000
R31156 MemRCol1156 MemRCol1204 1000.000000
R31205 MemRCol1205 MemRCol1254 1000.000000
R31255 MemRCol1255 MemRCol1305 1000.000000
R31306 MemRCol1306 MemRCol1357 1000.000000
R31358 MemRCol1358 MemRCol1410 1000.000000
R31411 MemRCol1411 MemRCol1464 1000.000000
R31465 MemRCol1465 MemRCol1519 1000.000000
R31520 MemRCol1520 MemRCol1575 1000.000000
R31576 MemRCol1576 MemRCol1632 1000.000000
R31633 MemRCol1633 MemRCol1690 1000.000000
R31691 MemRCol1691 MemRCol1749 1000.000000
R31750 MemRCol1750 MemRCol1809 1000.000000
R31810 MemRCol1810 MemRCol1870 1000.000000
R31871 MemRCol1871 MemRCol1932 1000.000000
R31933 MemRCol1933 MemRCol1995 1000.000000
R31996 MemRCol1996 MemRCol2059 1000.000000
R32060 MemRCol2060 MemRCol2124 1000.000000
R32125 MemRCol2125 MemRCol2190 1000.000000
R32191 MemRCol2191 MemRCol2257 1000.000000
R32258 MemRCol2258 MemRCol2325 1000.000000
R32326 MemRCol2326 MemRCol2394 1000.000000
R32395 MemRCol2395 MemRCol2464 1000.000000
R32465 MemRCol2465 MemRCol2535 1000.000000
R3232 MemRCol232 MemRCol254 1000.000000
R3255 MemRCol255 MemRCol278 1000.000000
R3279 MemRCol279 MemRCol303 1000.000000
R3304 MemRCol304 MemRCol329 1000.000000
R3330 MemRCol330 MemRCol356 1000.000000
R3357 MemRCol357 MemRCol384 1000.000000
R3385 MemRCol385 MemRCol413 1000.000000
R3414 MemRCol414 MemRCol443 1000.000000
R3444 MemRCol444 MemRCol474 1000.000000
R3475 MemRCol475 MemRCol506 1000.000000
R3507 MemRCol507 MemRCol539 1000.000000
R3540 MemRCol540 MemRCol573 1000.000000
R3574 MemRCol574 MemRCol608 1000.000000
R3609 MemRCol609 MemRCol644 1000.000000
R3645 MemRCol645 MemRCol681 1000.000000
R3682 MemRCol682 MemRCol719 1000.000000
R3720 MemRCol720 MemRCol758 1000.000000
R3759 MemRCol759 MemRCol798 1000.000000
R3799 MemRCol799 MemRCol839 1000.000000
R3840 MemRCol840 MemRCol881 1000.000000
R3882 MemRCol882 MemRCol924 1000.000000
R3925 MemRCol925 MemRCol968 1000.000000
R3969 MemRCol969 MemRCol1013 1000.000000
R31014 MemRCol1014 MemRCol1059 1000.000000
R31060 MemRCol1060 MemRCol1106 1000.000000
R31107 MemRCol1107 MemRCol1154 1000.000000
R31155 MemRCol1155 MemRCol1203 1000.000000
R31204 MemRCol1204 MemRCol1253 1000.000000
R31254 MemRCol1254 MemRCol1304 1000.000000
R31305 MemRCol1305 MemRCol1356 1000.000000
R31357 MemRCol1357 MemRCol1409 1000.000000
R31410 MemRCol1410 MemRCol1463 1000.000000
R31464 MemRCol1464 MemRCol1518 1000.000000
R31519 MemRCol1519 MemRCol1574 1000.000000
R31575 MemRCol1575 MemRCol1631 1000.000000
R31632 MemRCol1632 MemRCol1689 1000.000000
R31690 MemRCol1690 MemRCol1748 1000.000000
R31749 MemRCol1749 MemRCol1808 1000.000000
R31809 MemRCol1809 MemRCol1869 1000.000000
R31870 MemRCol1870 MemRCol1931 1000.000000
R31932 MemRCol1932 MemRCol1994 1000.000000
R31995 MemRCol1995 MemRCol2058 1000.000000
R32059 MemRCol2059 MemRCol2123 1000.000000
R32124 MemRCol2124 MemRCol2189 1000.000000
R32190 MemRCol2190 MemRCol2256 1000.000000
R32257 MemRCol2257 MemRCol2324 1000.000000
R32325 MemRCol2325 MemRCol2393 1000.000000
R32394 MemRCol2394 MemRCol2463 1000.000000
R32464 MemRCol2464 MemRCol2534 1000.000000
R32535 MemRCol2535 MemRCol2606 1000.000000
R3254 MemRCol254 MemRCol277 1000.000000
R3278 MemRCol278 MemRCol302 1000.000000
R3303 MemRCol303 MemRCol328 1000.000000
R3329 MemRCol329 MemRCol355 1000.000000
R3356 MemRCol356 MemRCol383 1000.000000
R3384 MemRCol384 MemRCol412 1000.000000
R3413 MemRCol413 MemRCol442 1000.000000
R3443 MemRCol443 MemRCol473 1000.000000
R3474 MemRCol474 MemRCol505 1000.000000
R3506 MemRCol506 MemRCol538 1000.000000
R3539 MemRCol539 MemRCol572 1000.000000
R3573 MemRCol573 MemRCol607 1000.000000
R3608 MemRCol608 MemRCol643 1000.000000
R3644 MemRCol644 MemRCol680 1000.000000
R3681 MemRCol681 MemRCol718 1000.000000
R3719 MemRCol719 MemRCol757 1000.000000
R3758 MemRCol758 MemRCol797 1000.000000
R3798 MemRCol798 MemRCol838 1000.000000
R3839 MemRCol839 MemRCol880 1000.000000
R3881 MemRCol881 MemRCol923 1000.000000
R3924 MemRCol924 MemRCol967 1000.000000
R3968 MemRCol968 MemRCol1012 1000.000000
R31013 MemRCol1013 MemRCol1058 1000.000000
R31059 MemRCol1059 MemRCol1105 1000.000000
R31106 MemRCol1106 MemRCol1153 1000.000000
R31154 MemRCol1154 MemRCol1202 1000.000000
R31203 MemRCol1203 MemRCol1252 1000.000000
R31253 MemRCol1253 MemRCol1303 1000.000000
R31304 MemRCol1304 MemRCol1355 1000.000000
R31356 MemRCol1356 MemRCol1408 1000.000000
R31409 MemRCol1409 MemRCol1462 1000.000000
R31463 MemRCol1463 MemRCol1517 1000.000000
R31518 MemRCol1518 MemRCol1573 1000.000000
R31574 MemRCol1574 MemRCol1630 1000.000000
R31631 MemRCol1631 MemRCol1688 1000.000000
R31689 MemRCol1689 MemRCol1747 1000.000000
R31748 MemRCol1748 MemRCol1807 1000.000000
R31808 MemRCol1808 MemRCol1868 1000.000000
R31869 MemRCol1869 MemRCol1930 1000.000000
R31931 MemRCol1931 MemRCol1993 1000.000000
R31994 MemRCol1994 MemRCol2057 1000.000000
R32058 MemRCol2058 MemRCol2122 1000.000000
R32123 MemRCol2123 MemRCol2188 1000.000000
R32189 MemRCol2189 MemRCol2255 1000.000000
R32256 MemRCol2256 MemRCol2323 1000.000000
R32324 MemRCol2324 MemRCol2392 1000.000000
R32393 MemRCol2393 MemRCol2462 1000.000000
R32463 MemRCol2463 MemRCol2533 1000.000000
R32534 MemRCol2534 MemRCol2605 1000.000000
R32606 MemRCol2606 MemRCol2678 1000.000000
R3277 MemRCol277 MemRCol301 1000.000000
R3302 MemRCol302 MemRCol327 1000.000000
R3328 MemRCol328 MemRCol354 1000.000000
R3355 MemRCol355 MemRCol382 1000.000000
R3383 MemRCol383 MemRCol411 1000.000000
R3412 MemRCol412 MemRCol441 1000.000000
R3442 MemRCol442 MemRCol472 1000.000000
R3473 MemRCol473 MemRCol504 1000.000000
R3505 MemRCol505 MemRCol537 1000.000000
R3538 MemRCol538 MemRCol571 1000.000000
R3572 MemRCol572 MemRCol606 1000.000000
R3607 MemRCol607 MemRCol642 1000.000000
R3643 MemRCol643 MemRCol679 1000.000000
R3680 MemRCol680 MemRCol717 1000.000000
R3718 MemRCol718 MemRCol756 1000.000000
R3757 MemRCol757 MemRCol796 1000.000000
R3797 MemRCol797 MemRCol837 1000.000000
R3838 MemRCol838 MemRCol879 1000.000000
R3880 MemRCol880 MemRCol922 1000.000000
R3923 MemRCol923 MemRCol966 1000.000000
R3967 MemRCol967 MemRCol1011 1000.000000
R31012 MemRCol1012 MemRCol1057 1000.000000
R31058 MemRCol1058 MemRCol1104 1000.000000
R31105 MemRCol1105 MemRCol1152 1000.000000
R31153 MemRCol1153 MemRCol1201 1000.000000
R31202 MemRCol1202 MemRCol1251 1000.000000
R31252 MemRCol1252 MemRCol1302 1000.000000
R31303 MemRCol1303 MemRCol1354 1000.000000
R31355 MemRCol1355 MemRCol1407 1000.000000
R31408 MemRCol1408 MemRCol1461 1000.000000
R31462 MemRCol1462 MemRCol1516 1000.000000
R31517 MemRCol1517 MemRCol1572 1000.000000
R31573 MemRCol1573 MemRCol1629 1000.000000
R31630 MemRCol1630 MemRCol1687 1000.000000
R31688 MemRCol1688 MemRCol1746 1000.000000
R31747 MemRCol1747 MemRCol1806 1000.000000
R31807 MemRCol1807 MemRCol1867 1000.000000
R31868 MemRCol1868 MemRCol1929 1000.000000
R31930 MemRCol1930 MemRCol1992 1000.000000
R31993 MemRCol1993 MemRCol2056 1000.000000
R32057 MemRCol2057 MemRCol2121 1000.000000
R32122 MemRCol2122 MemRCol2187 1000.000000
R32188 MemRCol2188 MemRCol2254 1000.000000
R32255 MemRCol2255 MemRCol2322 1000.000000
R32323 MemRCol2323 MemRCol2391 1000.000000
R32392 MemRCol2392 MemRCol2461 1000.000000
R32462 MemRCol2462 MemRCol2532 1000.000000
R32533 MemRCol2533 MemRCol2604 1000.000000
R32605 MemRCol2605 MemRCol2677 1000.000000
R32678 MemRCol2678 MemRCol2751 1000.000000
R3301 MemRCol301 MemRCol326 1000.000000
R3327 MemRCol327 MemRCol353 1000.000000
R3354 MemRCol354 MemRCol381 1000.000000
R3382 MemRCol382 MemRCol410 1000.000000
R3411 MemRCol411 MemRCol440 1000.000000
R3441 MemRCol441 MemRCol471 1000.000000
R3472 MemRCol472 MemRCol503 1000.000000
R3504 MemRCol504 MemRCol536 1000.000000
R3537 MemRCol537 MemRCol570 1000.000000
R3571 MemRCol571 MemRCol605 1000.000000
R3606 MemRCol606 MemRCol641 1000.000000
R3642 MemRCol642 MemRCol678 1000.000000
R3679 MemRCol679 MemRCol716 1000.000000
R3717 MemRCol717 MemRCol755 1000.000000
R3756 MemRCol756 MemRCol795 1000.000000
R3796 MemRCol796 MemRCol836 1000.000000
R3837 MemRCol837 MemRCol878 1000.000000
R3879 MemRCol879 MemRCol921 1000.000000
R3922 MemRCol922 MemRCol965 1000.000000
R3966 MemRCol966 MemRCol1010 1000.000000
R31011 MemRCol1011 MemRCol1056 1000.000000
R31057 MemRCol1057 MemRCol1103 1000.000000
R31104 MemRCol1104 MemRCol1151 1000.000000
R31152 MemRCol1152 MemRCol1200 1000.000000
R31201 MemRCol1201 MemRCol1250 1000.000000
R31251 MemRCol1251 MemRCol1301 1000.000000
R31302 MemRCol1302 MemRCol1353 1000.000000
R31354 MemRCol1354 MemRCol1406 1000.000000
R31407 MemRCol1407 MemRCol1460 1000.000000
R31461 MemRCol1461 MemRCol1515 1000.000000
R31516 MemRCol1516 MemRCol1571 1000.000000
R31572 MemRCol1572 MemRCol1628 1000.000000
R31629 MemRCol1629 MemRCol1686 1000.000000
R31687 MemRCol1687 MemRCol1745 1000.000000
R31746 MemRCol1746 MemRCol1805 1000.000000
R31806 MemRCol1806 MemRCol1866 1000.000000
R31867 MemRCol1867 MemRCol1928 1000.000000
R31929 MemRCol1929 MemRCol1991 1000.000000
R31992 MemRCol1992 MemRCol2055 1000.000000
R32056 MemRCol2056 MemRCol2120 1000.000000
R32121 MemRCol2121 MemRCol2186 1000.000000
R32187 MemRCol2187 MemRCol2253 1000.000000
R32254 MemRCol2254 MemRCol2321 1000.000000
R32322 MemRCol2322 MemRCol2390 1000.000000
R32391 MemRCol2391 MemRCol2460 1000.000000
R32461 MemRCol2461 MemRCol2531 1000.000000
R32532 MemRCol2532 MemRCol2603 1000.000000
R32604 MemRCol2604 MemRCol2676 1000.000000
R32677 MemRCol2677 MemRCol2750 1000.000000
R32751 MemRCol2751 MemRCol2825 1000.000000
R3326 MemRCol326 MemRCol352 1000.000000
R3353 MemRCol353 MemRCol380 1000.000000
R3381 MemRCol381 MemRCol409 1000.000000
R3410 MemRCol410 MemRCol439 1000.000000
R3440 MemRCol440 MemRCol470 1000.000000
R3471 MemRCol471 MemRCol502 1000.000000
R3503 MemRCol503 MemRCol535 1000.000000
R3536 MemRCol536 MemRCol569 1000.000000
R3570 MemRCol570 MemRCol604 1000.000000
R3605 MemRCol605 MemRCol640 1000.000000
R3641 MemRCol641 MemRCol677 1000.000000
R3678 MemRCol678 MemRCol715 1000.000000
R3716 MemRCol716 MemRCol754 1000.000000
R3755 MemRCol755 MemRCol794 1000.000000
R3795 MemRCol795 MemRCol835 1000.000000
R3836 MemRCol836 MemRCol877 1000.000000
R3878 MemRCol878 MemRCol920 1000.000000
R3921 MemRCol921 MemRCol964 1000.000000
R3965 MemRCol965 MemRCol1009 1000.000000
R31010 MemRCol1010 MemRCol1055 1000.000000
R31056 MemRCol1056 MemRCol1102 1000.000000
R31103 MemRCol1103 MemRCol1150 1000.000000
R31151 MemRCol1151 MemRCol1199 1000.000000
R31200 MemRCol1200 MemRCol1249 1000.000000
R31250 MemRCol1250 MemRCol1300 1000.000000
R31301 MemRCol1301 MemRCol1352 1000.000000
R31353 MemRCol1353 MemRCol1405 1000.000000
R31406 MemRCol1406 MemRCol1459 1000.000000
R31460 MemRCol1460 MemRCol1514 1000.000000
R31515 MemRCol1515 MemRCol1570 1000.000000
R31571 MemRCol1571 MemRCol1627 1000.000000
R31628 MemRCol1628 MemRCol1685 1000.000000
R31686 MemRCol1686 MemRCol1744 1000.000000
R31745 MemRCol1745 MemRCol1804 1000.000000
R31805 MemRCol1805 MemRCol1865 1000.000000
R31866 MemRCol1866 MemRCol1927 1000.000000
R31928 MemRCol1928 MemRCol1990 1000.000000
R31991 MemRCol1991 MemRCol2054 1000.000000
R32055 MemRCol2055 MemRCol2119 1000.000000
R32120 MemRCol2120 MemRCol2185 1000.000000
R32186 MemRCol2186 MemRCol2252 1000.000000
R32253 MemRCol2253 MemRCol2320 1000.000000
R32321 MemRCol2321 MemRCol2389 1000.000000
R32390 MemRCol2390 MemRCol2459 1000.000000
R32460 MemRCol2460 MemRCol2530 1000.000000
R32531 MemRCol2531 MemRCol2602 1000.000000
R32603 MemRCol2603 MemRCol2675 1000.000000
R32676 MemRCol2676 MemRCol2749 1000.000000
R32750 MemRCol2750 MemRCol2824 1000.000000
R32825 MemRCol2825 MemRCol2900 1000.000000
R3352 MemRCol352 MemRCol379 1000.000000
R3380 MemRCol380 MemRCol408 1000.000000
R3409 MemRCol409 MemRCol438 1000.000000
R3439 MemRCol439 MemRCol469 1000.000000
R3470 MemRCol470 MemRCol501 1000.000000
R3502 MemRCol502 MemRCol534 1000.000000
R3535 MemRCol535 MemRCol568 1000.000000
R3569 MemRCol569 MemRCol603 1000.000000
R3604 MemRCol604 MemRCol639 1000.000000
R3640 MemRCol640 MemRCol676 1000.000000
R3677 MemRCol677 MemRCol714 1000.000000
R3715 MemRCol715 MemRCol753 1000.000000
R3754 MemRCol754 MemRCol793 1000.000000
R3794 MemRCol794 MemRCol834 1000.000000
R3835 MemRCol835 MemRCol876 1000.000000
R3877 MemRCol877 MemRCol919 1000.000000
R3920 MemRCol920 MemRCol963 1000.000000
R3964 MemRCol964 MemRCol1008 1000.000000
R31009 MemRCol1009 MemRCol1054 1000.000000
R31055 MemRCol1055 MemRCol1101 1000.000000
R31102 MemRCol1102 MemRCol1149 1000.000000
R31150 MemRCol1150 MemRCol1198 1000.000000
R31199 MemRCol1199 MemRCol1248 1000.000000
R31249 MemRCol1249 MemRCol1299 1000.000000
R31300 MemRCol1300 MemRCol1351 1000.000000
R31352 MemRCol1352 MemRCol1404 1000.000000
R31405 MemRCol1405 MemRCol1458 1000.000000
R31459 MemRCol1459 MemRCol1513 1000.000000
R31514 MemRCol1514 MemRCol1569 1000.000000
R31570 MemRCol1570 MemRCol1626 1000.000000
R31627 MemRCol1627 MemRCol1684 1000.000000
R31685 MemRCol1685 MemRCol1743 1000.000000
R31744 MemRCol1744 MemRCol1803 1000.000000
R31804 MemRCol1804 MemRCol1864 1000.000000
R31865 MemRCol1865 MemRCol1926 1000.000000
R31927 MemRCol1927 MemRCol1989 1000.000000
R31990 MemRCol1990 MemRCol2053 1000.000000
R32054 MemRCol2054 MemRCol2118 1000.000000
R32119 MemRCol2119 MemRCol2184 1000.000000
R32185 MemRCol2185 MemRCol2251 1000.000000
R32252 MemRCol2252 MemRCol2319 1000.000000
R32320 MemRCol2320 MemRCol2388 1000.000000
R32389 MemRCol2389 MemRCol2458 1000.000000
R32459 MemRCol2459 MemRCol2529 1000.000000
R32530 MemRCol2530 MemRCol2601 1000.000000
R32602 MemRCol2602 MemRCol2674 1000.000000
R32675 MemRCol2675 MemRCol2748 1000.000000
R32749 MemRCol2749 MemRCol2823 1000.000000
R32824 MemRCol2824 MemRCol2899 1000.000000
R32900 MemRCol2900 MemRCol2976 1000.000000
R3379 MemRCol379 MemRCol407 1000.000000
R3408 MemRCol408 MemRCol437 1000.000000
R3438 MemRCol438 MemRCol468 1000.000000
R3469 MemRCol469 MemRCol500 1000.000000
R3501 MemRCol501 MemRCol533 1000.000000
R3534 MemRCol534 MemRCol567 1000.000000
R3568 MemRCol568 MemRCol602 1000.000000
R3603 MemRCol603 MemRCol638 1000.000000
R3639 MemRCol639 MemRCol675 1000.000000
R3676 MemRCol676 MemRCol713 1000.000000
R3714 MemRCol714 MemRCol752 1000.000000
R3753 MemRCol753 MemRCol792 1000.000000
R3793 MemRCol793 MemRCol833 1000.000000
R3834 MemRCol834 MemRCol875 1000.000000
R3876 MemRCol876 MemRCol918 1000.000000
R3919 MemRCol919 MemRCol962 1000.000000
R3963 MemRCol963 MemRCol1007 1000.000000
R31008 MemRCol1008 MemRCol1053 1000.000000
R31054 MemRCol1054 MemRCol1100 1000.000000
R31101 MemRCol1101 MemRCol1148 1000.000000
R31149 MemRCol1149 MemRCol1197 1000.000000
R31198 MemRCol1198 MemRCol1247 1000.000000
R31248 MemRCol1248 MemRCol1298 1000.000000
R31299 MemRCol1299 MemRCol1350 1000.000000
R31351 MemRCol1351 MemRCol1403 1000.000000
R31404 MemRCol1404 MemRCol1457 1000.000000
R31458 MemRCol1458 MemRCol1512 1000.000000
R31513 MemRCol1513 MemRCol1568 1000.000000
R31569 MemRCol1569 MemRCol1625 1000.000000
R31626 MemRCol1626 MemRCol1683 1000.000000
R31684 MemRCol1684 MemRCol1742 1000.000000
R31743 MemRCol1743 MemRCol1802 1000.000000
R31803 MemRCol1803 MemRCol1863 1000.000000
R31864 MemRCol1864 MemRCol1925 1000.000000
R31926 MemRCol1926 MemRCol1988 1000.000000
R31989 MemRCol1989 MemRCol2052 1000.000000
R32053 MemRCol2053 MemRCol2117 1000.000000
R32118 MemRCol2118 MemRCol2183 1000.000000
R32184 MemRCol2184 MemRCol2250 1000.000000
R32251 MemRCol2251 MemRCol2318 1000.000000
R32319 MemRCol2319 MemRCol2387 1000.000000
R32388 MemRCol2388 MemRCol2457 1000.000000
R32458 MemRCol2458 MemRCol2528 1000.000000
R32529 MemRCol2529 MemRCol2600 1000.000000
R32601 MemRCol2601 MemRCol2673 1000.000000
R32674 MemRCol2674 MemRCol2747 1000.000000
R32748 MemRCol2748 MemRCol2822 1000.000000
R32823 MemRCol2823 MemRCol2898 1000.000000
R32899 MemRCol2899 MemRCol2975 1000.000000
R32976 MemRCol2976 MemRCol3053 1000.000000
R3407 MemRCol407 MemRCol436 1000.000000
R3437 MemRCol437 MemRCol467 1000.000000
R3468 MemRCol468 MemRCol499 1000.000000
R3500 MemRCol500 MemRCol532 1000.000000
R3533 MemRCol533 MemRCol566 1000.000000
R3567 MemRCol567 MemRCol601 1000.000000
R3602 MemRCol602 MemRCol637 1000.000000
R3638 MemRCol638 MemRCol674 1000.000000
R3675 MemRCol675 MemRCol712 1000.000000
R3713 MemRCol713 MemRCol751 1000.000000
R3752 MemRCol752 MemRCol791 1000.000000
R3792 MemRCol792 MemRCol832 1000.000000
R3833 MemRCol833 MemRCol874 1000.000000
R3875 MemRCol875 MemRCol917 1000.000000
R3918 MemRCol918 MemRCol961 1000.000000
R3962 MemRCol962 MemRCol1006 1000.000000
R31007 MemRCol1007 MemRCol1052 1000.000000
R31053 MemRCol1053 MemRCol1099 1000.000000
R31100 MemRCol1100 MemRCol1147 1000.000000
R31148 MemRCol1148 MemRCol1196 1000.000000
R31197 MemRCol1197 MemRCol1246 1000.000000
R31247 MemRCol1247 MemRCol1297 1000.000000
R31298 MemRCol1298 MemRCol1349 1000.000000
R31350 MemRCol1350 MemRCol1402 1000.000000
R31403 MemRCol1403 MemRCol1456 1000.000000
R31457 MemRCol1457 MemRCol1511 1000.000000
R31512 MemRCol1512 MemRCol1567 1000.000000
R31568 MemRCol1568 MemRCol1624 1000.000000
R31625 MemRCol1625 MemRCol1682 1000.000000
R31683 MemRCol1683 MemRCol1741 1000.000000
R31742 MemRCol1742 MemRCol1801 1000.000000
R31802 MemRCol1802 MemRCol1862 1000.000000
R31863 MemRCol1863 MemRCol1924 1000.000000
R31925 MemRCol1925 MemRCol1987 1000.000000
R31988 MemRCol1988 MemRCol2051 1000.000000
R32052 MemRCol2052 MemRCol2116 1000.000000
R32117 MemRCol2117 MemRCol2182 1000.000000
R32183 MemRCol2183 MemRCol2249 1000.000000
R32250 MemRCol2250 MemRCol2317 1000.000000
R32318 MemRCol2318 MemRCol2386 1000.000000
R32387 MemRCol2387 MemRCol2456 1000.000000
R32457 MemRCol2457 MemRCol2527 1000.000000
R32528 MemRCol2528 MemRCol2599 1000.000000
R32600 MemRCol2600 MemRCol2672 1000.000000
R32673 MemRCol2673 MemRCol2746 1000.000000
R32747 MemRCol2747 MemRCol2821 1000.000000
R32822 MemRCol2822 MemRCol2897 1000.000000
R32898 MemRCol2898 MemRCol2974 1000.000000
R32975 MemRCol2975 MemRCol3052 1000.000000
R33053 MemRCol3053 MemRCol3131 1000.000000
R3436 MemRCol436 MemRCol466 1000.000000
R3467 MemRCol467 MemRCol498 1000.000000
R3499 MemRCol499 MemRCol531 1000.000000
R3532 MemRCol532 MemRCol565 1000.000000
R3566 MemRCol566 MemRCol600 1000.000000
R3601 MemRCol601 MemRCol636 1000.000000
R3637 MemRCol637 MemRCol673 1000.000000
R3674 MemRCol674 MemRCol711 1000.000000
R3712 MemRCol712 MemRCol750 1000.000000
R3751 MemRCol751 MemRCol790 1000.000000
R3791 MemRCol791 MemRCol831 1000.000000
R3832 MemRCol832 MemRCol873 1000.000000
R3874 MemRCol874 MemRCol916 1000.000000
R3917 MemRCol917 MemRCol960 1000.000000
R3961 MemRCol961 MemRCol1005 1000.000000
R31006 MemRCol1006 MemRCol1051 1000.000000
R31052 MemRCol1052 MemRCol1098 1000.000000
R31099 MemRCol1099 MemRCol1146 1000.000000
R31147 MemRCol1147 MemRCol1195 1000.000000
R31196 MemRCol1196 MemRCol1245 1000.000000
R31246 MemRCol1246 MemRCol1296 1000.000000
R31297 MemRCol1297 MemRCol1348 1000.000000
R31349 MemRCol1349 MemRCol1401 1000.000000
R31402 MemRCol1402 MemRCol1455 1000.000000
R31456 MemRCol1456 MemRCol1510 1000.000000
R31511 MemRCol1511 MemRCol1566 1000.000000
R31567 MemRCol1567 MemRCol1623 1000.000000
R31624 MemRCol1624 MemRCol1681 1000.000000
R31682 MemRCol1682 MemRCol1740 1000.000000
R31741 MemRCol1741 MemRCol1800 1000.000000
R31801 MemRCol1801 MemRCol1861 1000.000000
R31862 MemRCol1862 MemRCol1923 1000.000000
R31924 MemRCol1924 MemRCol1986 1000.000000
R31987 MemRCol1987 MemRCol2050 1000.000000
R32051 MemRCol2051 MemRCol2115 1000.000000
R32116 MemRCol2116 MemRCol2181 1000.000000
R32182 MemRCol2182 MemRCol2248 1000.000000
R32249 MemRCol2249 MemRCol2316 1000.000000
R32317 MemRCol2317 MemRCol2385 1000.000000
R32386 MemRCol2386 MemRCol2455 1000.000000
R32456 MemRCol2456 MemRCol2526 1000.000000
R32527 MemRCol2527 MemRCol2598 1000.000000
R32599 MemRCol2599 MemRCol2671 1000.000000
R32672 MemRCol2672 MemRCol2745 1000.000000
R32746 MemRCol2746 MemRCol2820 1000.000000
R32821 MemRCol2821 MemRCol2896 1000.000000
R32897 MemRCol2897 MemRCol2973 1000.000000
R32974 MemRCol2974 MemRCol3051 1000.000000
R33052 MemRCol3052 MemRCol3130 1000.000000
R33131 MemRCol3131 MemRCol3210 1000.000000
R3466 MemRCol466 MemRCol497 1000.000000
R3498 MemRCol498 MemRCol530 1000.000000
R3531 MemRCol531 MemRCol564 1000.000000
R3565 MemRCol565 MemRCol599 1000.000000
R3600 MemRCol600 MemRCol635 1000.000000
R3636 MemRCol636 MemRCol672 1000.000000
R3673 MemRCol673 MemRCol710 1000.000000
R3711 MemRCol711 MemRCol749 1000.000000
R3750 MemRCol750 MemRCol789 1000.000000
R3790 MemRCol790 MemRCol830 1000.000000
R3831 MemRCol831 MemRCol872 1000.000000
R3873 MemRCol873 MemRCol915 1000.000000
R3916 MemRCol916 MemRCol959 1000.000000
R3960 MemRCol960 MemRCol1004 1000.000000
R31005 MemRCol1005 MemRCol1050 1000.000000
R31051 MemRCol1051 MemRCol1097 1000.000000
R31098 MemRCol1098 MemRCol1145 1000.000000
R31146 MemRCol1146 MemRCol1194 1000.000000
R31195 MemRCol1195 MemRCol1244 1000.000000
R31245 MemRCol1245 MemRCol1295 1000.000000
R31296 MemRCol1296 MemRCol1347 1000.000000
R31348 MemRCol1348 MemRCol1400 1000.000000
R31401 MemRCol1401 MemRCol1454 1000.000000
R31455 MemRCol1455 MemRCol1509 1000.000000
R31510 MemRCol1510 MemRCol1565 1000.000000
R31566 MemRCol1566 MemRCol1622 1000.000000
R31623 MemRCol1623 MemRCol1680 1000.000000
R31681 MemRCol1681 MemRCol1739 1000.000000
R31740 MemRCol1740 MemRCol1799 1000.000000
R31800 MemRCol1800 MemRCol1860 1000.000000
R31861 MemRCol1861 MemRCol1922 1000.000000
R31923 MemRCol1923 MemRCol1985 1000.000000
R31986 MemRCol1986 MemRCol2049 1000.000000
R32050 MemRCol2050 MemRCol2114 1000.000000
R32115 MemRCol2115 MemRCol2180 1000.000000
R32181 MemRCol2181 MemRCol2247 1000.000000
R32248 MemRCol2248 MemRCol2315 1000.000000
R32316 MemRCol2316 MemRCol2384 1000.000000
R32385 MemRCol2385 MemRCol2454 1000.000000
R32455 MemRCol2455 MemRCol2525 1000.000000
R32526 MemRCol2526 MemRCol2597 1000.000000
R32598 MemRCol2598 MemRCol2670 1000.000000
R32671 MemRCol2671 MemRCol2744 1000.000000
R32745 MemRCol2745 MemRCol2819 1000.000000
R32820 MemRCol2820 MemRCol2895 1000.000000
R32896 MemRCol2896 MemRCol2972 1000.000000
R32973 MemRCol2973 MemRCol3050 1000.000000
R33051 MemRCol3051 MemRCol3129 1000.000000
R33130 MemRCol3130 MemRCol3209 1000.000000
R33210 MemRCol3210 MemRCol3290 1000.000000
R3497 MemRCol497 MemRCol529 1000.000000
R3530 MemRCol530 MemRCol563 1000.000000
R3564 MemRCol564 MemRCol598 1000.000000
R3599 MemRCol599 MemRCol634 1000.000000
R3635 MemRCol635 MemRCol671 1000.000000
R3672 MemRCol672 MemRCol709 1000.000000
R3710 MemRCol710 MemRCol748 1000.000000
R3749 MemRCol749 MemRCol788 1000.000000
R3789 MemRCol789 MemRCol829 1000.000000
R3830 MemRCol830 MemRCol871 1000.000000
R3872 MemRCol872 MemRCol914 1000.000000
R3915 MemRCol915 MemRCol958 1000.000000
R3959 MemRCol959 MemRCol1003 1000.000000
R31004 MemRCol1004 MemRCol1049 1000.000000
R31050 MemRCol1050 MemRCol1096 1000.000000
R31097 MemRCol1097 MemRCol1144 1000.000000
R31145 MemRCol1145 MemRCol1193 1000.000000
R31194 MemRCol1194 MemRCol1243 1000.000000
R31244 MemRCol1244 MemRCol1294 1000.000000
R31295 MemRCol1295 MemRCol1346 1000.000000
R31347 MemRCol1347 MemRCol1399 1000.000000
R31400 MemRCol1400 MemRCol1453 1000.000000
R31454 MemRCol1454 MemRCol1508 1000.000000
R31509 MemRCol1509 MemRCol1564 1000.000000
R31565 MemRCol1565 MemRCol1621 1000.000000
R31622 MemRCol1622 MemRCol1679 1000.000000
R31680 MemRCol1680 MemRCol1738 1000.000000
R31739 MemRCol1739 MemRCol1798 1000.000000
R31799 MemRCol1799 MemRCol1859 1000.000000
R31860 MemRCol1860 MemRCol1921 1000.000000
R31922 MemRCol1922 MemRCol1984 1000.000000
R31985 MemRCol1985 MemRCol2048 1000.000000
R32049 MemRCol2049 MemRCol2113 1000.000000
R32114 MemRCol2114 MemRCol2179 1000.000000
R32180 MemRCol2180 MemRCol2246 1000.000000
R32247 MemRCol2247 MemRCol2314 1000.000000
R32315 MemRCol2315 MemRCol2383 1000.000000
R32384 MemRCol2384 MemRCol2453 1000.000000
R32454 MemRCol2454 MemRCol2524 1000.000000
R32525 MemRCol2525 MemRCol2596 1000.000000
R32597 MemRCol2597 MemRCol2669 1000.000000
R32670 MemRCol2670 MemRCol2743 1000.000000
R32744 MemRCol2744 MemRCol2818 1000.000000
R32819 MemRCol2819 MemRCol2894 1000.000000
R32895 MemRCol2895 MemRCol2971 1000.000000
R32972 MemRCol2972 MemRCol3049 1000.000000
R33050 MemRCol3050 MemRCol3128 1000.000000
R33129 MemRCol3129 MemRCol3208 1000.000000
R33209 MemRCol3209 MemRCol3289 1000.000000
R33290 MemRCol3290 MemRCol3371 1000.000000
R3529 MemRCol529 MemRCol562 1000.000000
R3563 MemRCol563 MemRCol597 1000.000000
R3598 MemRCol598 MemRCol633 1000.000000
R3634 MemRCol634 MemRCol670 1000.000000
R3671 MemRCol671 MemRCol708 1000.000000
R3709 MemRCol709 MemRCol747 1000.000000
R3748 MemRCol748 MemRCol787 1000.000000
R3788 MemRCol788 MemRCol828 1000.000000
R3829 MemRCol829 MemRCol870 1000.000000
R3871 MemRCol871 MemRCol913 1000.000000
R3914 MemRCol914 MemRCol957 1000.000000
R3958 MemRCol958 MemRCol1002 1000.000000
R31003 MemRCol1003 MemRCol1048 1000.000000
R31049 MemRCol1049 MemRCol1095 1000.000000
R31096 MemRCol1096 MemRCol1143 1000.000000
R31144 MemRCol1144 MemRCol1192 1000.000000
R31193 MemRCol1193 MemRCol1242 1000.000000
R31243 MemRCol1243 MemRCol1293 1000.000000
R31294 MemRCol1294 MemRCol1345 1000.000000
R31346 MemRCol1346 MemRCol1398 1000.000000
R31399 MemRCol1399 MemRCol1452 1000.000000
R31453 MemRCol1453 MemRCol1507 1000.000000
R31508 MemRCol1508 MemRCol1563 1000.000000
R31564 MemRCol1564 MemRCol1620 1000.000000
R31621 MemRCol1621 MemRCol1678 1000.000000
R31679 MemRCol1679 MemRCol1737 1000.000000
R31738 MemRCol1738 MemRCol1797 1000.000000
R31798 MemRCol1798 MemRCol1858 1000.000000
R31859 MemRCol1859 MemRCol1920 1000.000000
R31921 MemRCol1921 MemRCol1983 1000.000000
R31984 MemRCol1984 MemRCol2047 1000.000000
R32048 MemRCol2048 MemRCol2112 1000.000000
R32113 MemRCol2113 MemRCol2178 1000.000000
R32179 MemRCol2179 MemRCol2245 1000.000000
R32246 MemRCol2246 MemRCol2313 1000.000000
R32314 MemRCol2314 MemRCol2382 1000.000000
R32383 MemRCol2383 MemRCol2452 1000.000000
R32453 MemRCol2453 MemRCol2523 1000.000000
R32524 MemRCol2524 MemRCol2595 1000.000000
R32596 MemRCol2596 MemRCol2668 1000.000000
R32669 MemRCol2669 MemRCol2742 1000.000000
R32743 MemRCol2743 MemRCol2817 1000.000000
R32818 MemRCol2818 MemRCol2893 1000.000000
R32894 MemRCol2894 MemRCol2970 1000.000000
R32971 MemRCol2971 MemRCol3048 1000.000000
R33049 MemRCol3049 MemRCol3127 1000.000000
R33128 MemRCol3128 MemRCol3207 1000.000000
R33208 MemRCol3208 MemRCol3288 1000.000000
R33289 MemRCol3289 MemRCol3370 1000.000000
R33371 MemRCol3371 MemRCol3453 1000.000000
R3562 MemRCol562 MemRCol596 1000.000000
R3597 MemRCol597 MemRCol632 1000.000000
R3633 MemRCol633 MemRCol669 1000.000000
R3670 MemRCol670 MemRCol707 1000.000000
R3708 MemRCol708 MemRCol746 1000.000000
R3747 MemRCol747 MemRCol786 1000.000000
R3787 MemRCol787 MemRCol827 1000.000000
R3828 MemRCol828 MemRCol869 1000.000000
R3870 MemRCol870 MemRCol912 1000.000000
R3913 MemRCol913 MemRCol956 1000.000000
R3957 MemRCol957 MemRCol1001 1000.000000
R31002 MemRCol1002 MemRCol1047 1000.000000
R31048 MemRCol1048 MemRCol1094 1000.000000
R31095 MemRCol1095 MemRCol1142 1000.000000
R31143 MemRCol1143 MemRCol1191 1000.000000
R31192 MemRCol1192 MemRCol1241 1000.000000
R31242 MemRCol1242 MemRCol1292 1000.000000
R31293 MemRCol1293 MemRCol1344 1000.000000
R31345 MemRCol1345 MemRCol1397 1000.000000
R31398 MemRCol1398 MemRCol1451 1000.000000
R31452 MemRCol1452 MemRCol1506 1000.000000
R31507 MemRCol1507 MemRCol1562 1000.000000
R31563 MemRCol1563 MemRCol1619 1000.000000
R31620 MemRCol1620 MemRCol1677 1000.000000
R31678 MemRCol1678 MemRCol1736 1000.000000
R31737 MemRCol1737 MemRCol1796 1000.000000
R31797 MemRCol1797 MemRCol1857 1000.000000
R31858 MemRCol1858 MemRCol1919 1000.000000
R31920 MemRCol1920 MemRCol1982 1000.000000
R31983 MemRCol1983 MemRCol2046 1000.000000
R32047 MemRCol2047 MemRCol2111 1000.000000
R32112 MemRCol2112 MemRCol2177 1000.000000
R32178 MemRCol2178 MemRCol2244 1000.000000
R32245 MemRCol2245 MemRCol2312 1000.000000
R32313 MemRCol2313 MemRCol2381 1000.000000
R32382 MemRCol2382 MemRCol2451 1000.000000
R32452 MemRCol2452 MemRCol2522 1000.000000
R32523 MemRCol2523 MemRCol2594 1000.000000
R32595 MemRCol2595 MemRCol2667 1000.000000
R32668 MemRCol2668 MemRCol2741 1000.000000
R32742 MemRCol2742 MemRCol2816 1000.000000
R32817 MemRCol2817 MemRCol2892 1000.000000
R32893 MemRCol2893 MemRCol2969 1000.000000
R32970 MemRCol2970 MemRCol3047 1000.000000
R33048 MemRCol3048 MemRCol3126 1000.000000
R33127 MemRCol3127 MemRCol3206 1000.000000
R33207 MemRCol3207 MemRCol3287 1000.000000
R33288 MemRCol3288 MemRCol3369 1000.000000
R33370 MemRCol3370 MemRCol3452 1000.000000
R33453 MemRCol3453 MemRCol3536 1000.000000
R3596 MemRCol596 MemRCol631 1000.000000
R3632 MemRCol632 MemRCol668 1000.000000
R3669 MemRCol669 MemRCol706 1000.000000
R3707 MemRCol707 MemRCol745 1000.000000
R3746 MemRCol746 MemRCol785 1000.000000
R3786 MemRCol786 MemRCol826 1000.000000
R3827 MemRCol827 MemRCol868 1000.000000
R3869 MemRCol869 MemRCol911 1000.000000
R3912 MemRCol912 MemRCol955 1000.000000
R3956 MemRCol956 MemRCol1000 1000.000000
R31001 MemRCol1001 MemRCol1046 1000.000000
R31047 MemRCol1047 MemRCol1093 1000.000000
R31094 MemRCol1094 MemRCol1141 1000.000000
R31142 MemRCol1142 MemRCol1190 1000.000000
R31191 MemRCol1191 MemRCol1240 1000.000000
R31241 MemRCol1241 MemRCol1291 1000.000000
R31292 MemRCol1292 MemRCol1343 1000.000000
R31344 MemRCol1344 MemRCol1396 1000.000000
R31397 MemRCol1397 MemRCol1450 1000.000000
R31451 MemRCol1451 MemRCol1505 1000.000000
R31506 MemRCol1506 MemRCol1561 1000.000000
R31562 MemRCol1562 MemRCol1618 1000.000000
R31619 MemRCol1619 MemRCol1676 1000.000000
R31677 MemRCol1677 MemRCol1735 1000.000000
R31736 MemRCol1736 MemRCol1795 1000.000000
R31796 MemRCol1796 MemRCol1856 1000.000000
R31857 MemRCol1857 MemRCol1918 1000.000000
R31919 MemRCol1919 MemRCol1981 1000.000000
R31982 MemRCol1982 MemRCol2045 1000.000000
R32046 MemRCol2046 MemRCol2110 1000.000000
R32111 MemRCol2111 MemRCol2176 1000.000000
R32177 MemRCol2177 MemRCol2243 1000.000000
R32244 MemRCol2244 MemRCol2311 1000.000000
R32312 MemRCol2312 MemRCol2380 1000.000000
R32381 MemRCol2381 MemRCol2450 1000.000000
R32451 MemRCol2451 MemRCol2521 1000.000000
R32522 MemRCol2522 MemRCol2593 1000.000000
R32594 MemRCol2594 MemRCol2666 1000.000000
R32667 MemRCol2667 MemRCol2740 1000.000000
R32741 MemRCol2741 MemRCol2815 1000.000000
R32816 MemRCol2816 MemRCol2891 1000.000000
R32892 MemRCol2892 MemRCol2968 1000.000000
R32969 MemRCol2969 MemRCol3046 1000.000000
R33047 MemRCol3047 MemRCol3125 1000.000000
R33126 MemRCol3126 MemRCol3205 1000.000000
R33206 MemRCol3206 MemRCol3286 1000.000000
R33287 MemRCol3287 MemRCol3368 1000.000000
R33369 MemRCol3369 MemRCol3451 1000.000000
R33452 MemRCol3452 MemRCol3535 1000.000000
R33536 MemRCol3536 MemRCol3620 1000.000000
R3631 MemRCol631 MemRCol667 1000.000000
R3668 MemRCol668 MemRCol705 1000.000000
R3706 MemRCol706 MemRCol744 1000.000000
R3745 MemRCol745 MemRCol784 1000.000000
R3785 MemRCol785 MemRCol825 1000.000000
R3826 MemRCol826 MemRCol867 1000.000000
R3868 MemRCol868 MemRCol910 1000.000000
R3911 MemRCol911 MemRCol954 1000.000000
R3955 MemRCol955 MemRCol999 1000.000000
R31000 MemRCol1000 MemRCol1045 1000.000000
R31046 MemRCol1046 MemRCol1092 1000.000000
R31093 MemRCol1093 MemRCol1140 1000.000000
R31141 MemRCol1141 MemRCol1189 1000.000000
R31190 MemRCol1190 MemRCol1239 1000.000000
R31240 MemRCol1240 MemRCol1290 1000.000000
R31291 MemRCol1291 MemRCol1342 1000.000000
R31343 MemRCol1343 MemRCol1395 1000.000000
R31396 MemRCol1396 MemRCol1449 1000.000000
R31450 MemRCol1450 MemRCol1504 1000.000000
R31505 MemRCol1505 MemRCol1560 1000.000000
R31561 MemRCol1561 MemRCol1617 1000.000000
R31618 MemRCol1618 MemRCol1675 1000.000000
R31676 MemRCol1676 MemRCol1734 1000.000000
R31735 MemRCol1735 MemRCol1794 1000.000000
R31795 MemRCol1795 MemRCol1855 1000.000000
R31856 MemRCol1856 MemRCol1917 1000.000000
R31918 MemRCol1918 MemRCol1980 1000.000000
R31981 MemRCol1981 MemRCol2044 1000.000000
R32045 MemRCol2045 MemRCol2109 1000.000000
R32110 MemRCol2110 MemRCol2175 1000.000000
R32176 MemRCol2176 MemRCol2242 1000.000000
R32243 MemRCol2243 MemRCol2310 1000.000000
R32311 MemRCol2311 MemRCol2379 1000.000000
R32380 MemRCol2380 MemRCol2449 1000.000000
R32450 MemRCol2450 MemRCol2520 1000.000000
R32521 MemRCol2521 MemRCol2592 1000.000000
R32593 MemRCol2593 MemRCol2665 1000.000000
R32666 MemRCol2666 MemRCol2739 1000.000000
R32740 MemRCol2740 MemRCol2814 1000.000000
R32815 MemRCol2815 MemRCol2890 1000.000000
R32891 MemRCol2891 MemRCol2967 1000.000000
R32968 MemRCol2968 MemRCol3045 1000.000000
R33046 MemRCol3046 MemRCol3124 1000.000000
R33125 MemRCol3125 MemRCol3204 1000.000000
R33205 MemRCol3205 MemRCol3285 1000.000000
R33286 MemRCol3286 MemRCol3367 1000.000000
R33368 MemRCol3368 MemRCol3450 1000.000000
R33451 MemRCol3451 MemRCol3534 1000.000000
R33535 MemRCol3535 MemRCol3619 1000.000000
R33620 MemRCol3620 MemRCol3705 1000.000000
R3667 MemRCol667 MemRCol704 1000.000000
R3705 MemRCol705 MemRCol743 1000.000000
R3744 MemRCol744 MemRCol783 1000.000000
R3784 MemRCol784 MemRCol824 1000.000000
R3825 MemRCol825 MemRCol866 1000.000000
R3867 MemRCol867 MemRCol909 1000.000000
R3910 MemRCol910 MemRCol953 1000.000000
R3954 MemRCol954 MemRCol998 1000.000000
R3999 MemRCol999 MemRCol1044 1000.000000
R31045 MemRCol1045 MemRCol1091 1000.000000
R31092 MemRCol1092 MemRCol1139 1000.000000
R31140 MemRCol1140 MemRCol1188 1000.000000
R31189 MemRCol1189 MemRCol1238 1000.000000
R31239 MemRCol1239 MemRCol1289 1000.000000
R31290 MemRCol1290 MemRCol1341 1000.000000
R31342 MemRCol1342 MemRCol1394 1000.000000
R31395 MemRCol1395 MemRCol1448 1000.000000
R31449 MemRCol1449 MemRCol1503 1000.000000
R31504 MemRCol1504 MemRCol1559 1000.000000
R31560 MemRCol1560 MemRCol1616 1000.000000
R31617 MemRCol1617 MemRCol1674 1000.000000
R31675 MemRCol1675 MemRCol1733 1000.000000
R31734 MemRCol1734 MemRCol1793 1000.000000
R31794 MemRCol1794 MemRCol1854 1000.000000
R31855 MemRCol1855 MemRCol1916 1000.000000
R31917 MemRCol1917 MemRCol1979 1000.000000
R31980 MemRCol1980 MemRCol2043 1000.000000
R32044 MemRCol2044 MemRCol2108 1000.000000
R32109 MemRCol2109 MemRCol2174 1000.000000
R32175 MemRCol2175 MemRCol2241 1000.000000
R32242 MemRCol2242 MemRCol2309 1000.000000
R32310 MemRCol2310 MemRCol2378 1000.000000
R32379 MemRCol2379 MemRCol2448 1000.000000
R32449 MemRCol2449 MemRCol2519 1000.000000
R32520 MemRCol2520 MemRCol2591 1000.000000
R32592 MemRCol2592 MemRCol2664 1000.000000
R32665 MemRCol2665 MemRCol2738 1000.000000
R32739 MemRCol2739 MemRCol2813 1000.000000
R32814 MemRCol2814 MemRCol2889 1000.000000
R32890 MemRCol2890 MemRCol2966 1000.000000
R32967 MemRCol2967 MemRCol3044 1000.000000
R33045 MemRCol3045 MemRCol3123 1000.000000
R33124 MemRCol3124 MemRCol3203 1000.000000
R33204 MemRCol3204 MemRCol3284 1000.000000
R33285 MemRCol3285 MemRCol3366 1000.000000
R33367 MemRCol3367 MemRCol3449 1000.000000
R33450 MemRCol3450 MemRCol3533 1000.000000
R33534 MemRCol3534 MemRCol3618 1000.000000
R33619 MemRCol3619 MemRCol3704 1000.000000
R33705 MemRCol3705 MemRCol3791 1000.000000
R3704 MemRCol704 MemRCol742 1000.000000
R3743 MemRCol743 MemRCol782 1000.000000
R3783 MemRCol783 MemRCol823 1000.000000
R3824 MemRCol824 MemRCol865 1000.000000
R3866 MemRCol866 MemRCol908 1000.000000
R3909 MemRCol909 MemRCol952 1000.000000
R3953 MemRCol953 MemRCol997 1000.000000
R3998 MemRCol998 MemRCol1043 1000.000000
R31044 MemRCol1044 MemRCol1090 1000.000000
R31091 MemRCol1091 MemRCol1138 1000.000000
R31139 MemRCol1139 MemRCol1187 1000.000000
R31188 MemRCol1188 MemRCol1237 1000.000000
R31238 MemRCol1238 MemRCol1288 1000.000000
R31289 MemRCol1289 MemRCol1340 1000.000000
R31341 MemRCol1341 MemRCol1393 1000.000000
R31394 MemRCol1394 MemRCol1447 1000.000000
R31448 MemRCol1448 MemRCol1502 1000.000000
R31503 MemRCol1503 MemRCol1558 1000.000000
R31559 MemRCol1559 MemRCol1615 1000.000000
R31616 MemRCol1616 MemRCol1673 1000.000000
R31674 MemRCol1674 MemRCol1732 1000.000000
R31733 MemRCol1733 MemRCol1792 1000.000000
R31793 MemRCol1793 MemRCol1853 1000.000000
R31854 MemRCol1854 MemRCol1915 1000.000000
R31916 MemRCol1916 MemRCol1978 1000.000000
R31979 MemRCol1979 MemRCol2042 1000.000000
R32043 MemRCol2043 MemRCol2107 1000.000000
R32108 MemRCol2108 MemRCol2173 1000.000000
R32174 MemRCol2174 MemRCol2240 1000.000000
R32241 MemRCol2241 MemRCol2308 1000.000000
R32309 MemRCol2309 MemRCol2377 1000.000000
R32378 MemRCol2378 MemRCol2447 1000.000000
R32448 MemRCol2448 MemRCol2518 1000.000000
R32519 MemRCol2519 MemRCol2590 1000.000000
R32591 MemRCol2591 MemRCol2663 1000.000000
R32664 MemRCol2664 MemRCol2737 1000.000000
R32738 MemRCol2738 MemRCol2812 1000.000000
R32813 MemRCol2813 MemRCol2888 1000.000000
R32889 MemRCol2889 MemRCol2965 1000.000000
R32966 MemRCol2966 MemRCol3043 1000.000000
R33044 MemRCol3044 MemRCol3122 1000.000000
R33123 MemRCol3123 MemRCol3202 1000.000000
R33203 MemRCol3203 MemRCol3283 1000.000000
R33284 MemRCol3284 MemRCol3365 1000.000000
R33366 MemRCol3366 MemRCol3448 1000.000000
R33449 MemRCol3449 MemRCol3532 1000.000000
R33533 MemRCol3533 MemRCol3617 1000.000000
R33618 MemRCol3618 MemRCol3703 1000.000000
R33704 MemRCol3704 MemRCol3790 1000.000000
R33791 MemRCol3791 MemRCol3878 1000.000000
R3742 MemRCol742 MemRCol781 1000.000000
R3782 MemRCol782 MemRCol822 1000.000000
R3823 MemRCol823 MemRCol864 1000.000000
R3865 MemRCol865 MemRCol907 1000.000000
R3908 MemRCol908 MemRCol951 1000.000000
R3952 MemRCol952 MemRCol996 1000.000000
R3997 MemRCol997 MemRCol1042 1000.000000
R31043 MemRCol1043 MemRCol1089 1000.000000
R31090 MemRCol1090 MemRCol1137 1000.000000
R31138 MemRCol1138 MemRCol1186 1000.000000
R31187 MemRCol1187 MemRCol1236 1000.000000
R31237 MemRCol1237 MemRCol1287 1000.000000
R31288 MemRCol1288 MemRCol1339 1000.000000
R31340 MemRCol1340 MemRCol1392 1000.000000
R31393 MemRCol1393 MemRCol1446 1000.000000
R31447 MemRCol1447 MemRCol1501 1000.000000
R31502 MemRCol1502 MemRCol1557 1000.000000
R31558 MemRCol1558 MemRCol1614 1000.000000
R31615 MemRCol1615 MemRCol1672 1000.000000
R31673 MemRCol1673 MemRCol1731 1000.000000
R31732 MemRCol1732 MemRCol1791 1000.000000
R31792 MemRCol1792 MemRCol1852 1000.000000
R31853 MemRCol1853 MemRCol1914 1000.000000
R31915 MemRCol1915 MemRCol1977 1000.000000
R31978 MemRCol1978 MemRCol2041 1000.000000
R32042 MemRCol2042 MemRCol2106 1000.000000
R32107 MemRCol2107 MemRCol2172 1000.000000
R32173 MemRCol2173 MemRCol2239 1000.000000
R32240 MemRCol2240 MemRCol2307 1000.000000
R32308 MemRCol2308 MemRCol2376 1000.000000
R32377 MemRCol2377 MemRCol2446 1000.000000
R32447 MemRCol2447 MemRCol2517 1000.000000
R32518 MemRCol2518 MemRCol2589 1000.000000
R32590 MemRCol2590 MemRCol2662 1000.000000
R32663 MemRCol2663 MemRCol2736 1000.000000
R32737 MemRCol2737 MemRCol2811 1000.000000
R32812 MemRCol2812 MemRCol2887 1000.000000
R32888 MemRCol2888 MemRCol2964 1000.000000
R32965 MemRCol2965 MemRCol3042 1000.000000
R33043 MemRCol3043 MemRCol3121 1000.000000
R33122 MemRCol3122 MemRCol3201 1000.000000
R33202 MemRCol3202 MemRCol3282 1000.000000
R33283 MemRCol3283 MemRCol3364 1000.000000
R33365 MemRCol3365 MemRCol3447 1000.000000
R33448 MemRCol3448 MemRCol3531 1000.000000
R33532 MemRCol3532 MemRCol3616 1000.000000
R33617 MemRCol3617 MemRCol3702 1000.000000
R33703 MemRCol3703 MemRCol3789 1000.000000
R33790 MemRCol3790 MemRCol3877 1000.000000
R33878 MemRCol3878 MemRCol3966 1000.000000
R3781 MemRCol781 MemRCol821 1000.000000
R3822 MemRCol822 MemRCol863 1000.000000
R3864 MemRCol864 MemRCol906 1000.000000
R3907 MemRCol907 MemRCol950 1000.000000
R3951 MemRCol951 MemRCol995 1000.000000
R3996 MemRCol996 MemRCol1041 1000.000000
R31042 MemRCol1042 MemRCol1088 1000.000000
R31089 MemRCol1089 MemRCol1136 1000.000000
R31137 MemRCol1137 MemRCol1185 1000.000000
R31186 MemRCol1186 MemRCol1235 1000.000000
R31236 MemRCol1236 MemRCol1286 1000.000000
R31287 MemRCol1287 MemRCol1338 1000.000000
R31339 MemRCol1339 MemRCol1391 1000.000000
R31392 MemRCol1392 MemRCol1445 1000.000000
R31446 MemRCol1446 MemRCol1500 1000.000000
R31501 MemRCol1501 MemRCol1556 1000.000000
R31557 MemRCol1557 MemRCol1613 1000.000000
R31614 MemRCol1614 MemRCol1671 1000.000000
R31672 MemRCol1672 MemRCol1730 1000.000000
R31731 MemRCol1731 MemRCol1790 1000.000000
R31791 MemRCol1791 MemRCol1851 1000.000000
R31852 MemRCol1852 MemRCol1913 1000.000000
R31914 MemRCol1914 MemRCol1976 1000.000000
R31977 MemRCol1977 MemRCol2040 1000.000000
R32041 MemRCol2041 MemRCol2105 1000.000000
R32106 MemRCol2106 MemRCol2171 1000.000000
R32172 MemRCol2172 MemRCol2238 1000.000000
R32239 MemRCol2239 MemRCol2306 1000.000000
R32307 MemRCol2307 MemRCol2375 1000.000000
R32376 MemRCol2376 MemRCol2445 1000.000000
R32446 MemRCol2446 MemRCol2516 1000.000000
R32517 MemRCol2517 MemRCol2588 1000.000000
R32589 MemRCol2589 MemRCol2661 1000.000000
R32662 MemRCol2662 MemRCol2735 1000.000000
R32736 MemRCol2736 MemRCol2810 1000.000000
R32811 MemRCol2811 MemRCol2886 1000.000000
R32887 MemRCol2887 MemRCol2963 1000.000000
R32964 MemRCol2964 MemRCol3041 1000.000000
R33042 MemRCol3042 MemRCol3120 1000.000000
R33121 MemRCol3121 MemRCol3200 1000.000000
R33201 MemRCol3201 MemRCol3281 1000.000000
R33282 MemRCol3282 MemRCol3363 1000.000000
R33364 MemRCol3364 MemRCol3446 1000.000000
R33447 MemRCol3447 MemRCol3530 1000.000000
R33531 MemRCol3531 MemRCol3615 1000.000000
R33616 MemRCol3616 MemRCol3701 1000.000000
R33702 MemRCol3702 MemRCol3788 1000.000000
R33789 MemRCol3789 MemRCol3876 1000.000000
R33877 MemRCol3877 MemRCol3965 1000.000000
R33966 MemRCol3966 MemRCol4055 1000.000000
R3821 MemRCol821 MemRCol862 1000.000000
R3863 MemRCol863 MemRCol905 1000.000000
R3906 MemRCol906 MemRCol949 1000.000000
R3950 MemRCol950 MemRCol994 1000.000000
R3995 MemRCol995 MemRCol1040 1000.000000
R31041 MemRCol1041 MemRCol1087 1000.000000
R31088 MemRCol1088 MemRCol1135 1000.000000
R31136 MemRCol1136 MemRCol1184 1000.000000
R31185 MemRCol1185 MemRCol1234 1000.000000
R31235 MemRCol1235 MemRCol1285 1000.000000
R31286 MemRCol1286 MemRCol1337 1000.000000
R31338 MemRCol1338 MemRCol1390 1000.000000
R31391 MemRCol1391 MemRCol1444 1000.000000
R31445 MemRCol1445 MemRCol1499 1000.000000
R31500 MemRCol1500 MemRCol1555 1000.000000
R31556 MemRCol1556 MemRCol1612 1000.000000
R31613 MemRCol1613 MemRCol1670 1000.000000
R31671 MemRCol1671 MemRCol1729 1000.000000
R31730 MemRCol1730 MemRCol1789 1000.000000
R31790 MemRCol1790 MemRCol1850 1000.000000
R31851 MemRCol1851 MemRCol1912 1000.000000
R31913 MemRCol1913 MemRCol1975 1000.000000
R31976 MemRCol1976 MemRCol2039 1000.000000
R32040 MemRCol2040 MemRCol2104 1000.000000
R32105 MemRCol2105 MemRCol2170 1000.000000
R32171 MemRCol2171 MemRCol2237 1000.000000
R32238 MemRCol2238 MemRCol2305 1000.000000
R32306 MemRCol2306 MemRCol2374 1000.000000
R32375 MemRCol2375 MemRCol2444 1000.000000
R32445 MemRCol2445 MemRCol2515 1000.000000
R32516 MemRCol2516 MemRCol2587 1000.000000
R32588 MemRCol2588 MemRCol2660 1000.000000
R32661 MemRCol2661 MemRCol2734 1000.000000
R32735 MemRCol2735 MemRCol2809 1000.000000
R32810 MemRCol2810 MemRCol2885 1000.000000
R32886 MemRCol2886 MemRCol2962 1000.000000
R32963 MemRCol2963 MemRCol3040 1000.000000
R33041 MemRCol3041 MemRCol3119 1000.000000
R33120 MemRCol3120 MemRCol3199 1000.000000
R33200 MemRCol3200 MemRCol3280 1000.000000
R33281 MemRCol3281 MemRCol3362 1000.000000
R33363 MemRCol3363 MemRCol3445 1000.000000
R33446 MemRCol3446 MemRCol3529 1000.000000
R33530 MemRCol3530 MemRCol3614 1000.000000
R33615 MemRCol3615 MemRCol3700 1000.000000
R33701 MemRCol3701 MemRCol3787 1000.000000
R33788 MemRCol3788 MemRCol3875 1000.000000
R33876 MemRCol3876 MemRCol3964 1000.000000
R33965 MemRCol3965 MemRCol4054 1000.000000
R34055 MemRCol4055 MemRCol4145 1000.000000
R3862 MemRCol862 MemRCol904 1000.000000
R3905 MemRCol905 MemRCol948 1000.000000
R3949 MemRCol949 MemRCol993 1000.000000
R3994 MemRCol994 MemRCol1039 1000.000000
R31040 MemRCol1040 MemRCol1086 1000.000000
R31087 MemRCol1087 MemRCol1134 1000.000000
R31135 MemRCol1135 MemRCol1183 1000.000000
R31184 MemRCol1184 MemRCol1233 1000.000000
R31234 MemRCol1234 MemRCol1284 1000.000000
R31285 MemRCol1285 MemRCol1336 1000.000000
R31337 MemRCol1337 MemRCol1389 1000.000000
R31390 MemRCol1390 MemRCol1443 1000.000000
R31444 MemRCol1444 MemRCol1498 1000.000000
R31499 MemRCol1499 MemRCol1554 1000.000000
R31555 MemRCol1555 MemRCol1611 1000.000000
R31612 MemRCol1612 MemRCol1669 1000.000000
R31670 MemRCol1670 MemRCol1728 1000.000000
R31729 MemRCol1729 MemRCol1788 1000.000000
R31789 MemRCol1789 MemRCol1849 1000.000000
R31850 MemRCol1850 MemRCol1911 1000.000000
R31912 MemRCol1912 MemRCol1974 1000.000000
R31975 MemRCol1975 MemRCol2038 1000.000000
R32039 MemRCol2039 MemRCol2103 1000.000000
R32104 MemRCol2104 MemRCol2169 1000.000000
R32170 MemRCol2170 MemRCol2236 1000.000000
R32237 MemRCol2237 MemRCol2304 1000.000000
R32305 MemRCol2305 MemRCol2373 1000.000000
R32374 MemRCol2374 MemRCol2443 1000.000000
R32444 MemRCol2444 MemRCol2514 1000.000000
R32515 MemRCol2515 MemRCol2586 1000.000000
R32587 MemRCol2587 MemRCol2659 1000.000000
R32660 MemRCol2660 MemRCol2733 1000.000000
R32734 MemRCol2734 MemRCol2808 1000.000000
R32809 MemRCol2809 MemRCol2884 1000.000000
R32885 MemRCol2885 MemRCol2961 1000.000000
R32962 MemRCol2962 MemRCol3039 1000.000000
R33040 MemRCol3040 MemRCol3118 1000.000000
R33119 MemRCol3119 MemRCol3198 1000.000000
R33199 MemRCol3199 MemRCol3279 1000.000000
R33280 MemRCol3280 MemRCol3361 1000.000000
R33362 MemRCol3362 MemRCol3444 1000.000000
R33445 MemRCol3445 MemRCol3528 1000.000000
R33529 MemRCol3529 MemRCol3613 1000.000000
R33614 MemRCol3614 MemRCol3699 1000.000000
R33700 MemRCol3700 MemRCol3786 1000.000000
R33787 MemRCol3787 MemRCol3874 1000.000000
R33875 MemRCol3875 MemRCol3963 1000.000000
R33964 MemRCol3964 MemRCol4053 1000.000000
R34054 MemRCol4054 MemRCol4144 1000.000000
R34145 MemRCol4145 MemRCol4236 1000.000000
R3904 MemRCol904 MemRCol947 1000.000000
R3948 MemRCol948 MemRCol992 1000.000000
R3993 MemRCol993 MemRCol1038 1000.000000
R31039 MemRCol1039 MemRCol1085 1000.000000
R31086 MemRCol1086 MemRCol1133 1000.000000
R31134 MemRCol1134 MemRCol1182 1000.000000
R31183 MemRCol1183 MemRCol1232 1000.000000
R31233 MemRCol1233 MemRCol1283 1000.000000
R31284 MemRCol1284 MemRCol1335 1000.000000
R31336 MemRCol1336 MemRCol1388 1000.000000
R31389 MemRCol1389 MemRCol1442 1000.000000
R31443 MemRCol1443 MemRCol1497 1000.000000
R31498 MemRCol1498 MemRCol1553 1000.000000
R31554 MemRCol1554 MemRCol1610 1000.000000
R31611 MemRCol1611 MemRCol1668 1000.000000
R31669 MemRCol1669 MemRCol1727 1000.000000
R31728 MemRCol1728 MemRCol1787 1000.000000
R31788 MemRCol1788 MemRCol1848 1000.000000
R31849 MemRCol1849 MemRCol1910 1000.000000
R31911 MemRCol1911 MemRCol1973 1000.000000
R31974 MemRCol1974 MemRCol2037 1000.000000
R32038 MemRCol2038 MemRCol2102 1000.000000
R32103 MemRCol2103 MemRCol2168 1000.000000
R32169 MemRCol2169 MemRCol2235 1000.000000
R32236 MemRCol2236 MemRCol2303 1000.000000
R32304 MemRCol2304 MemRCol2372 1000.000000
R32373 MemRCol2373 MemRCol2442 1000.000000
R32443 MemRCol2443 MemRCol2513 1000.000000
R32514 MemRCol2514 MemRCol2585 1000.000000
R32586 MemRCol2586 MemRCol2658 1000.000000
R32659 MemRCol2659 MemRCol2732 1000.000000
R32733 MemRCol2733 MemRCol2807 1000.000000
R32808 MemRCol2808 MemRCol2883 1000.000000
R32884 MemRCol2884 MemRCol2960 1000.000000
R32961 MemRCol2961 MemRCol3038 1000.000000
R33039 MemRCol3039 MemRCol3117 1000.000000
R33118 MemRCol3118 MemRCol3197 1000.000000
R33198 MemRCol3198 MemRCol3278 1000.000000
R33279 MemRCol3279 MemRCol3360 1000.000000
R33361 MemRCol3361 MemRCol3443 1000.000000
R33444 MemRCol3444 MemRCol3527 1000.000000
R33528 MemRCol3528 MemRCol3612 1000.000000
R33613 MemRCol3613 MemRCol3698 1000.000000
R33699 MemRCol3699 MemRCol3785 1000.000000
R33786 MemRCol3786 MemRCol3873 1000.000000
R33874 MemRCol3874 MemRCol3962 1000.000000
R33963 MemRCol3963 MemRCol4052 1000.000000
R34053 MemRCol4053 MemRCol4143 1000.000000
R34144 MemRCol4144 MemRCol4235 1000.000000
R34236 MemRCol4236 MemRCol4328 1000.000000
R3947 MemRCol947 MemRCol991 1000.000000
R3992 MemRCol992 MemRCol1037 1000.000000
R31038 MemRCol1038 MemRCol1084 1000.000000
R31085 MemRCol1085 MemRCol1132 1000.000000
R31133 MemRCol1133 MemRCol1181 1000.000000
R31182 MemRCol1182 MemRCol1231 1000.000000
R31232 MemRCol1232 MemRCol1282 1000.000000
R31283 MemRCol1283 MemRCol1334 1000.000000
R31335 MemRCol1335 MemRCol1387 1000.000000
R31388 MemRCol1388 MemRCol1441 1000.000000
R31442 MemRCol1442 MemRCol1496 1000.000000
R31497 MemRCol1497 MemRCol1552 1000.000000
R31553 MemRCol1553 MemRCol1609 1000.000000
R31610 MemRCol1610 MemRCol1667 1000.000000
R31668 MemRCol1668 MemRCol1726 1000.000000
R31727 MemRCol1727 MemRCol1786 1000.000000
R31787 MemRCol1787 MemRCol1847 1000.000000
R31848 MemRCol1848 MemRCol1909 1000.000000
R31910 MemRCol1910 MemRCol1972 1000.000000
R31973 MemRCol1973 MemRCol2036 1000.000000
R32037 MemRCol2037 MemRCol2101 1000.000000
R32102 MemRCol2102 MemRCol2167 1000.000000
R32168 MemRCol2168 MemRCol2234 1000.000000
R32235 MemRCol2235 MemRCol2302 1000.000000
R32303 MemRCol2303 MemRCol2371 1000.000000
R32372 MemRCol2372 MemRCol2441 1000.000000
R32442 MemRCol2442 MemRCol2512 1000.000000
R32513 MemRCol2513 MemRCol2584 1000.000000
R32585 MemRCol2585 MemRCol2657 1000.000000
R32658 MemRCol2658 MemRCol2731 1000.000000
R32732 MemRCol2732 MemRCol2806 1000.000000
R32807 MemRCol2807 MemRCol2882 1000.000000
R32883 MemRCol2883 MemRCol2959 1000.000000
R32960 MemRCol2960 MemRCol3037 1000.000000
R33038 MemRCol3038 MemRCol3116 1000.000000
R33117 MemRCol3117 MemRCol3196 1000.000000
R33197 MemRCol3197 MemRCol3277 1000.000000
R33278 MemRCol3278 MemRCol3359 1000.000000
R33360 MemRCol3360 MemRCol3442 1000.000000
R33443 MemRCol3443 MemRCol3526 1000.000000
R33527 MemRCol3527 MemRCol3611 1000.000000
R33612 MemRCol3612 MemRCol3697 1000.000000
R33698 MemRCol3698 MemRCol3784 1000.000000
R33785 MemRCol3785 MemRCol3872 1000.000000
R33873 MemRCol3873 MemRCol3961 1000.000000
R33962 MemRCol3962 MemRCol4051 1000.000000
R34052 MemRCol4052 MemRCol4142 1000.000000
R34143 MemRCol4143 MemRCol4234 1000.000000
R34235 MemRCol4235 MemRCol4327 1000.000000
R34328 MemRCol4328 MemRCol4421 1000.000000
R3991 MemRCol991 MemRCol1036 1000.000000
R31037 MemRCol1037 MemRCol1083 1000.000000
R31084 MemRCol1084 MemRCol1131 1000.000000
R31132 MemRCol1132 MemRCol1180 1000.000000
R31181 MemRCol1181 MemRCol1230 1000.000000
R31231 MemRCol1231 MemRCol1281 1000.000000
R31282 MemRCol1282 MemRCol1333 1000.000000
R31334 MemRCol1334 MemRCol1386 1000.000000
R31387 MemRCol1387 MemRCol1440 1000.000000
R31441 MemRCol1441 MemRCol1495 1000.000000
R31496 MemRCol1496 MemRCol1551 1000.000000
R31552 MemRCol1552 MemRCol1608 1000.000000
R31609 MemRCol1609 MemRCol1666 1000.000000
R31667 MemRCol1667 MemRCol1725 1000.000000
R31726 MemRCol1726 MemRCol1785 1000.000000
R31786 MemRCol1786 MemRCol1846 1000.000000
R31847 MemRCol1847 MemRCol1908 1000.000000
R31909 MemRCol1909 MemRCol1971 1000.000000
R31972 MemRCol1972 MemRCol2035 1000.000000
R32036 MemRCol2036 MemRCol2100 1000.000000
R32101 MemRCol2101 MemRCol2166 1000.000000
R32167 MemRCol2167 MemRCol2233 1000.000000
R32234 MemRCol2234 MemRCol2301 1000.000000
R32302 MemRCol2302 MemRCol2370 1000.000000
R32371 MemRCol2371 MemRCol2440 1000.000000
R32441 MemRCol2441 MemRCol2511 1000.000000
R32512 MemRCol2512 MemRCol2583 1000.000000
R32584 MemRCol2584 MemRCol2656 1000.000000
R32657 MemRCol2657 MemRCol2730 1000.000000
R32731 MemRCol2731 MemRCol2805 1000.000000
R32806 MemRCol2806 MemRCol2881 1000.000000
R32882 MemRCol2882 MemRCol2958 1000.000000
R32959 MemRCol2959 MemRCol3036 1000.000000
R33037 MemRCol3037 MemRCol3115 1000.000000
R33116 MemRCol3116 MemRCol3195 1000.000000
R33196 MemRCol3196 MemRCol3276 1000.000000
R33277 MemRCol3277 MemRCol3358 1000.000000
R33359 MemRCol3359 MemRCol3441 1000.000000
R33442 MemRCol3442 MemRCol3525 1000.000000
R33526 MemRCol3526 MemRCol3610 1000.000000
R33611 MemRCol3611 MemRCol3696 1000.000000
R33697 MemRCol3697 MemRCol3783 1000.000000
R33784 MemRCol3784 MemRCol3871 1000.000000
R33872 MemRCol3872 MemRCol3960 1000.000000
R33961 MemRCol3961 MemRCol4050 1000.000000
R34051 MemRCol4051 MemRCol4141 1000.000000
R34142 MemRCol4142 MemRCol4233 1000.000000
R34234 MemRCol4234 MemRCol4326 1000.000000
R34327 MemRCol4327 MemRCol4420 1000.000000
R34421 MemRCol4421 MemRCol4515 1000.000000
R31036 MemRCol1036 MemRCol1082 1000.000000
R31083 MemRCol1083 MemRCol1130 1000.000000
R31131 MemRCol1131 MemRCol1179 1000.000000
R31180 MemRCol1180 MemRCol1229 1000.000000
R31230 MemRCol1230 MemRCol1280 1000.000000
R31281 MemRCol1281 MemRCol1332 1000.000000
R31333 MemRCol1333 MemRCol1385 1000.000000
R31386 MemRCol1386 MemRCol1439 1000.000000
R31440 MemRCol1440 MemRCol1494 1000.000000
R31495 MemRCol1495 MemRCol1550 1000.000000
R31551 MemRCol1551 MemRCol1607 1000.000000
R31608 MemRCol1608 MemRCol1665 1000.000000
R31666 MemRCol1666 MemRCol1724 1000.000000
R31725 MemRCol1725 MemRCol1784 1000.000000
R31785 MemRCol1785 MemRCol1845 1000.000000
R31846 MemRCol1846 MemRCol1907 1000.000000
R31908 MemRCol1908 MemRCol1970 1000.000000
R31971 MemRCol1971 MemRCol2034 1000.000000
R32035 MemRCol2035 MemRCol2099 1000.000000
R32100 MemRCol2100 MemRCol2165 1000.000000
R32166 MemRCol2166 MemRCol2232 1000.000000
R32233 MemRCol2233 MemRCol2300 1000.000000
R32301 MemRCol2301 MemRCol2369 1000.000000
R32370 MemRCol2370 MemRCol2439 1000.000000
R32440 MemRCol2440 MemRCol2510 1000.000000
R32511 MemRCol2511 MemRCol2582 1000.000000
R32583 MemRCol2583 MemRCol2655 1000.000000
R32656 MemRCol2656 MemRCol2729 1000.000000
R32730 MemRCol2730 MemRCol2804 1000.000000
R32805 MemRCol2805 MemRCol2880 1000.000000
R32881 MemRCol2881 MemRCol2957 1000.000000
R32958 MemRCol2958 MemRCol3035 1000.000000
R33036 MemRCol3036 MemRCol3114 1000.000000
R33115 MemRCol3115 MemRCol3194 1000.000000
R33195 MemRCol3195 MemRCol3275 1000.000000
R33276 MemRCol3276 MemRCol3357 1000.000000
R33358 MemRCol3358 MemRCol3440 1000.000000
R33441 MemRCol3441 MemRCol3524 1000.000000
R33525 MemRCol3525 MemRCol3609 1000.000000
R33610 MemRCol3610 MemRCol3695 1000.000000
R33696 MemRCol3696 MemRCol3782 1000.000000
R33783 MemRCol3783 MemRCol3870 1000.000000
R33871 MemRCol3871 MemRCol3959 1000.000000
R33960 MemRCol3960 MemRCol4049 1000.000000
R34050 MemRCol4050 MemRCol4140 1000.000000
R34141 MemRCol4141 MemRCol4232 1000.000000
R34233 MemRCol4233 MemRCol4325 1000.000000
R34326 MemRCol4326 MemRCol4419 1000.000000
R34420 MemRCol4420 MemRCol4514 1000.000000
R34515 MemRCol4515 MemRCol4610 1000.000000
R31082 MemRCol1082 MemRCol1129 1000.000000
R31130 MemRCol1130 MemRCol1178 1000.000000
R31179 MemRCol1179 MemRCol1228 1000.000000
R31229 MemRCol1229 MemRCol1279 1000.000000
R31280 MemRCol1280 MemRCol1331 1000.000000
R31332 MemRCol1332 MemRCol1384 1000.000000
R31385 MemRCol1385 MemRCol1438 1000.000000
R31439 MemRCol1439 MemRCol1493 1000.000000
R31494 MemRCol1494 MemRCol1549 1000.000000
R31550 MemRCol1550 MemRCol1606 1000.000000
R31607 MemRCol1607 MemRCol1664 1000.000000
R31665 MemRCol1665 MemRCol1723 1000.000000
R31724 MemRCol1724 MemRCol1783 1000.000000
R31784 MemRCol1784 MemRCol1844 1000.000000
R31845 MemRCol1845 MemRCol1906 1000.000000
R31907 MemRCol1907 MemRCol1969 1000.000000
R31970 MemRCol1970 MemRCol2033 1000.000000
R32034 MemRCol2034 MemRCol2098 1000.000000
R32099 MemRCol2099 MemRCol2164 1000.000000
R32165 MemRCol2165 MemRCol2231 1000.000000
R32232 MemRCol2232 MemRCol2299 1000.000000
R32300 MemRCol2300 MemRCol2368 1000.000000
R32369 MemRCol2369 MemRCol2438 1000.000000
R32439 MemRCol2439 MemRCol2509 1000.000000
R32510 MemRCol2510 MemRCol2581 1000.000000
R32582 MemRCol2582 MemRCol2654 1000.000000
R32655 MemRCol2655 MemRCol2728 1000.000000
R32729 MemRCol2729 MemRCol2803 1000.000000
R32804 MemRCol2804 MemRCol2879 1000.000000
R32880 MemRCol2880 MemRCol2956 1000.000000
R32957 MemRCol2957 MemRCol3034 1000.000000
R33035 MemRCol3035 MemRCol3113 1000.000000
R33114 MemRCol3114 MemRCol3193 1000.000000
R33194 MemRCol3194 MemRCol3274 1000.000000
R33275 MemRCol3275 MemRCol3356 1000.000000
R33357 MemRCol3357 MemRCol3439 1000.000000
R33440 MemRCol3440 MemRCol3523 1000.000000
R33524 MemRCol3524 MemRCol3608 1000.000000
R33609 MemRCol3609 MemRCol3694 1000.000000
R33695 MemRCol3695 MemRCol3781 1000.000000
R33782 MemRCol3782 MemRCol3869 1000.000000
R33870 MemRCol3870 MemRCol3958 1000.000000
R33959 MemRCol3959 MemRCol4048 1000.000000
R34049 MemRCol4049 MemRCol4139 1000.000000
R34140 MemRCol4140 MemRCol4231 1000.000000
R34232 MemRCol4232 MemRCol4324 1000.000000
R34325 MemRCol4325 MemRCol4418 1000.000000
R34419 MemRCol4419 MemRCol4513 1000.000000
R34514 MemRCol4514 MemRCol4609 1000.000000
R34610 MemRCol4610 MemRCol4706 1000.000000
R31129 MemRCol1129 MemRCol1177 1000.000000
R31178 MemRCol1178 MemRCol1227 1000.000000
R31228 MemRCol1228 MemRCol1278 1000.000000
R31279 MemRCol1279 MemRCol1330 1000.000000
R31331 MemRCol1331 MemRCol1383 1000.000000
R31384 MemRCol1384 MemRCol1437 1000.000000
R31438 MemRCol1438 MemRCol1492 1000.000000
R31493 MemRCol1493 MemRCol1548 1000.000000
R31549 MemRCol1549 MemRCol1605 1000.000000
R31606 MemRCol1606 MemRCol1663 1000.000000
R31664 MemRCol1664 MemRCol1722 1000.000000
R31723 MemRCol1723 MemRCol1782 1000.000000
R31783 MemRCol1783 MemRCol1843 1000.000000
R31844 MemRCol1844 MemRCol1905 1000.000000
R31906 MemRCol1906 MemRCol1968 1000.000000
R31969 MemRCol1969 MemRCol2032 1000.000000
R32033 MemRCol2033 MemRCol2097 1000.000000
R32098 MemRCol2098 MemRCol2163 1000.000000
R32164 MemRCol2164 MemRCol2230 1000.000000
R32231 MemRCol2231 MemRCol2298 1000.000000
R32299 MemRCol2299 MemRCol2367 1000.000000
R32368 MemRCol2368 MemRCol2437 1000.000000
R32438 MemRCol2438 MemRCol2508 1000.000000
R32509 MemRCol2509 MemRCol2580 1000.000000
R32581 MemRCol2581 MemRCol2653 1000.000000
R32654 MemRCol2654 MemRCol2727 1000.000000
R32728 MemRCol2728 MemRCol2802 1000.000000
R32803 MemRCol2803 MemRCol2878 1000.000000
R32879 MemRCol2879 MemRCol2955 1000.000000
R32956 MemRCol2956 MemRCol3033 1000.000000
R33034 MemRCol3034 MemRCol3112 1000.000000
R33113 MemRCol3113 MemRCol3192 1000.000000
R33193 MemRCol3193 MemRCol3273 1000.000000
R33274 MemRCol3274 MemRCol3355 1000.000000
R33356 MemRCol3356 MemRCol3438 1000.000000
R33439 MemRCol3439 MemRCol3522 1000.000000
R33523 MemRCol3523 MemRCol3607 1000.000000
R33608 MemRCol3608 MemRCol3693 1000.000000
R33694 MemRCol3694 MemRCol3780 1000.000000
R33781 MemRCol3781 MemRCol3868 1000.000000
R33869 MemRCol3869 MemRCol3957 1000.000000
R33958 MemRCol3958 MemRCol4047 1000.000000
R34048 MemRCol4048 MemRCol4138 1000.000000
R34139 MemRCol4139 MemRCol4230 1000.000000
R34231 MemRCol4231 MemRCol4323 1000.000000
R34324 MemRCol4324 MemRCol4417 1000.000000
R34418 MemRCol4418 MemRCol4512 1000.000000
R34513 MemRCol4513 MemRCol4608 1000.000000
R34609 MemRCol4609 MemRCol4705 1000.000000
R34706 MemRCol4706 MemRCol4803 1000.000000
R31177 MemRCol1177 MemRCol1226 1000.000000
R31227 MemRCol1227 MemRCol1277 1000.000000
R31278 MemRCol1278 MemRCol1329 1000.000000
R31330 MemRCol1330 MemRCol1382 1000.000000
R31383 MemRCol1383 MemRCol1436 1000.000000
R31437 MemRCol1437 MemRCol1491 1000.000000
R31492 MemRCol1492 MemRCol1547 1000.000000
R31548 MemRCol1548 MemRCol1604 1000.000000
R31605 MemRCol1605 MemRCol1662 1000.000000
R31663 MemRCol1663 MemRCol1721 1000.000000
R31722 MemRCol1722 MemRCol1781 1000.000000
R31782 MemRCol1782 MemRCol1842 1000.000000
R31843 MemRCol1843 MemRCol1904 1000.000000
R31905 MemRCol1905 MemRCol1967 1000.000000
R31968 MemRCol1968 MemRCol2031 1000.000000
R32032 MemRCol2032 MemRCol2096 1000.000000
R32097 MemRCol2097 MemRCol2162 1000.000000
R32163 MemRCol2163 MemRCol2229 1000.000000
R32230 MemRCol2230 MemRCol2297 1000.000000
R32298 MemRCol2298 MemRCol2366 1000.000000
R32367 MemRCol2367 MemRCol2436 1000.000000
R32437 MemRCol2437 MemRCol2507 1000.000000
R32508 MemRCol2508 MemRCol2579 1000.000000
R32580 MemRCol2580 MemRCol2652 1000.000000
R32653 MemRCol2653 MemRCol2726 1000.000000
R32727 MemRCol2727 MemRCol2801 1000.000000
R32802 MemRCol2802 MemRCol2877 1000.000000
R32878 MemRCol2878 MemRCol2954 1000.000000
R32955 MemRCol2955 MemRCol3032 1000.000000
R33033 MemRCol3033 MemRCol3111 1000.000000
R33112 MemRCol3112 MemRCol3191 1000.000000
R33192 MemRCol3192 MemRCol3272 1000.000000
R33273 MemRCol3273 MemRCol3354 1000.000000
R33355 MemRCol3355 MemRCol3437 1000.000000
R33438 MemRCol3438 MemRCol3521 1000.000000
R33522 MemRCol3522 MemRCol3606 1000.000000
R33607 MemRCol3607 MemRCol3692 1000.000000
R33693 MemRCol3693 MemRCol3779 1000.000000
R33780 MemRCol3780 MemRCol3867 1000.000000
R33868 MemRCol3868 MemRCol3956 1000.000000
R33957 MemRCol3957 MemRCol4046 1000.000000
R34047 MemRCol4047 MemRCol4137 1000.000000
R34138 MemRCol4138 MemRCol4229 1000.000000
R34230 MemRCol4230 MemRCol4322 1000.000000
R34323 MemRCol4323 MemRCol4416 1000.000000
R34417 MemRCol4417 MemRCol4511 1000.000000
R34512 MemRCol4512 MemRCol4607 1000.000000
R34608 MemRCol4608 MemRCol4704 1000.000000
R34705 MemRCol4705 MemRCol4802 1000.000000
R34803 MemRCol4803 MemRCol4901 1000.000000
R31226 MemRCol1226 MemRCol1276 1000.000000
R31277 MemRCol1277 MemRCol1328 1000.000000
R31329 MemRCol1329 MemRCol1381 1000.000000
R31382 MemRCol1382 MemRCol1435 1000.000000
R31436 MemRCol1436 MemRCol1490 1000.000000
R31491 MemRCol1491 MemRCol1546 1000.000000
R31547 MemRCol1547 MemRCol1603 1000.000000
R31604 MemRCol1604 MemRCol1661 1000.000000
R31662 MemRCol1662 MemRCol1720 1000.000000
R31721 MemRCol1721 MemRCol1780 1000.000000
R31781 MemRCol1781 MemRCol1841 1000.000000
R31842 MemRCol1842 MemRCol1903 1000.000000
R31904 MemRCol1904 MemRCol1966 1000.000000
R31967 MemRCol1967 MemRCol2030 1000.000000
R32031 MemRCol2031 MemRCol2095 1000.000000
R32096 MemRCol2096 MemRCol2161 1000.000000
R32162 MemRCol2162 MemRCol2228 1000.000000
R32229 MemRCol2229 MemRCol2296 1000.000000
R32297 MemRCol2297 MemRCol2365 1000.000000
R32366 MemRCol2366 MemRCol2435 1000.000000
R32436 MemRCol2436 MemRCol2506 1000.000000
R32507 MemRCol2507 MemRCol2578 1000.000000
R32579 MemRCol2579 MemRCol2651 1000.000000
R32652 MemRCol2652 MemRCol2725 1000.000000
R32726 MemRCol2726 MemRCol2800 1000.000000
R32801 MemRCol2801 MemRCol2876 1000.000000
R32877 MemRCol2877 MemRCol2953 1000.000000
R32954 MemRCol2954 MemRCol3031 1000.000000
R33032 MemRCol3032 MemRCol3110 1000.000000
R33111 MemRCol3111 MemRCol3190 1000.000000
R33191 MemRCol3191 MemRCol3271 1000.000000
R33272 MemRCol3272 MemRCol3353 1000.000000
R33354 MemRCol3354 MemRCol3436 1000.000000
R33437 MemRCol3437 MemRCol3520 1000.000000
R33521 MemRCol3521 MemRCol3605 1000.000000
R33606 MemRCol3606 MemRCol3691 1000.000000
R33692 MemRCol3692 MemRCol3778 1000.000000
R33779 MemRCol3779 MemRCol3866 1000.000000
R33867 MemRCol3867 MemRCol3955 1000.000000
R33956 MemRCol3956 MemRCol4045 1000.000000
R34046 MemRCol4046 MemRCol4136 1000.000000
R34137 MemRCol4137 MemRCol4228 1000.000000
R34229 MemRCol4229 MemRCol4321 1000.000000
R34322 MemRCol4322 MemRCol4415 1000.000000
R34416 MemRCol4416 MemRCol4510 1000.000000
R34511 MemRCol4511 MemRCol4606 1000.000000
R34607 MemRCol4607 MemRCol4703 1000.000000
R34704 MemRCol4704 MemRCol4801 1000.000000
R34802 MemRCol4802 MemRCol4900 1000.000000
R34901 MemRCol4901 MemRCol5000 1000.000000
R31276 MemRCol1276 MemRCol1327 1000.000000
R31328 MemRCol1328 MemRCol1380 1000.000000
R31381 MemRCol1381 MemRCol1434 1000.000000
R31435 MemRCol1435 MemRCol1489 1000.000000
R31490 MemRCol1490 MemRCol1545 1000.000000
R31546 MemRCol1546 MemRCol1602 1000.000000
R31603 MemRCol1603 MemRCol1660 1000.000000
R31661 MemRCol1661 MemRCol1719 1000.000000
R31720 MemRCol1720 MemRCol1779 1000.000000
R31780 MemRCol1780 MemRCol1840 1000.000000
R31841 MemRCol1841 MemRCol1902 1000.000000
R31903 MemRCol1903 MemRCol1965 1000.000000
R31966 MemRCol1966 MemRCol2029 1000.000000
R32030 MemRCol2030 MemRCol2094 1000.000000
R32095 MemRCol2095 MemRCol2160 1000.000000
R32161 MemRCol2161 MemRCol2227 1000.000000
R32228 MemRCol2228 MemRCol2295 1000.000000
R32296 MemRCol2296 MemRCol2364 1000.000000
R32365 MemRCol2365 MemRCol2434 1000.000000
R32435 MemRCol2435 MemRCol2505 1000.000000
R32506 MemRCol2506 MemRCol2577 1000.000000
R32578 MemRCol2578 MemRCol2650 1000.000000
R32651 MemRCol2651 MemRCol2724 1000.000000
R32725 MemRCol2725 MemRCol2799 1000.000000
R32800 MemRCol2800 MemRCol2875 1000.000000
R32876 MemRCol2876 MemRCol2952 1000.000000
R32953 MemRCol2953 MemRCol3030 1000.000000
R33031 MemRCol3031 MemRCol3109 1000.000000
R33110 MemRCol3110 MemRCol3189 1000.000000
R33190 MemRCol3190 MemRCol3270 1000.000000
R33271 MemRCol3271 MemRCol3352 1000.000000
R33353 MemRCol3353 MemRCol3435 1000.000000
R33436 MemRCol3436 MemRCol3519 1000.000000
R33520 MemRCol3520 MemRCol3604 1000.000000
R33605 MemRCol3605 MemRCol3690 1000.000000
R33691 MemRCol3691 MemRCol3777 1000.000000
R33778 MemRCol3778 MemRCol3865 1000.000000
R33866 MemRCol3866 MemRCol3954 1000.000000
R33955 MemRCol3955 MemRCol4044 1000.000000
R34045 MemRCol4045 MemRCol4135 1000.000000
R34136 MemRCol4136 MemRCol4227 1000.000000
R34228 MemRCol4228 MemRCol4320 1000.000000
R34321 MemRCol4321 MemRCol4414 1000.000000
R34415 MemRCol4415 MemRCol4509 1000.000000
R34510 MemRCol4510 MemRCol4605 1000.000000
R34606 MemRCol4606 MemRCol4702 1000.000000
R34703 MemRCol4703 MemRCol4800 1000.000000
R34801 MemRCol4801 MemRCol4899 1000.000000
R34900 MemRCol4900 MemRCol4999 1000.000000
R35000 MemRCol5000 MemRCol5100 1000.000000
R31327 MemRCol1327 MemRCol1379 1000.000000
R31380 MemRCol1380 MemRCol1433 1000.000000
R31434 MemRCol1434 MemRCol1488 1000.000000
R31489 MemRCol1489 MemRCol1544 1000.000000
R31545 MemRCol1545 MemRCol1601 1000.000000
R31602 MemRCol1602 MemRCol1659 1000.000000
R31660 MemRCol1660 MemRCol1718 1000.000000
R31719 MemRCol1719 MemRCol1778 1000.000000
R31779 MemRCol1779 MemRCol1839 1000.000000
R31840 MemRCol1840 MemRCol1901 1000.000000
R31902 MemRCol1902 MemRCol1964 1000.000000
R31965 MemRCol1965 MemRCol2028 1000.000000
R32029 MemRCol2029 MemRCol2093 1000.000000
R32094 MemRCol2094 MemRCol2159 1000.000000
R32160 MemRCol2160 MemRCol2226 1000.000000
R32227 MemRCol2227 MemRCol2294 1000.000000
R32295 MemRCol2295 MemRCol2363 1000.000000
R32364 MemRCol2364 MemRCol2433 1000.000000
R32434 MemRCol2434 MemRCol2504 1000.000000
R32505 MemRCol2505 MemRCol2576 1000.000000
R32577 MemRCol2577 MemRCol2649 1000.000000
R32650 MemRCol2650 MemRCol2723 1000.000000
R32724 MemRCol2724 MemRCol2798 1000.000000
R32799 MemRCol2799 MemRCol2874 1000.000000
R32875 MemRCol2875 MemRCol2951 1000.000000
R32952 MemRCol2952 MemRCol3029 1000.000000
R33030 MemRCol3030 MemRCol3108 1000.000000
R33109 MemRCol3109 MemRCol3188 1000.000000
R33189 MemRCol3189 MemRCol3269 1000.000000
R33270 MemRCol3270 MemRCol3351 1000.000000
R33352 MemRCol3352 MemRCol3434 1000.000000
R33435 MemRCol3435 MemRCol3518 1000.000000
R33519 MemRCol3519 MemRCol3603 1000.000000
R33604 MemRCol3604 MemRCol3689 1000.000000
R33690 MemRCol3690 MemRCol3776 1000.000000
R33777 MemRCol3777 MemRCol3864 1000.000000
R33865 MemRCol3865 MemRCol3953 1000.000000
R33954 MemRCol3954 MemRCol4043 1000.000000
R34044 MemRCol4044 MemRCol4134 1000.000000
R34135 MemRCol4135 MemRCol4226 1000.000000
R34227 MemRCol4227 MemRCol4319 1000.000000
R34320 MemRCol4320 MemRCol4413 1000.000000
R34414 MemRCol4414 MemRCol4508 1000.000000
R34509 MemRCol4509 MemRCol4604 1000.000000
R34605 MemRCol4605 MemRCol4701 1000.000000
R34702 MemRCol4702 MemRCol4799 1000.000000
R34800 MemRCol4800 MemRCol4898 1000.000000
R34899 MemRCol4899 MemRCol4998 1000.000000
R34999 MemRCol4999 MemRCol5099 1000.000000
R35100 MemRCol5100 MemRCol5201 1000.000000

*Column 'Ammeter' Resistances
R51 MemRCol1379 0 0.000000001000
R52 MemRCol1433 0 0.000000001000
R53 MemRCol1488 0 0.000000001000
R54 MemRCol1544 0 0.000000001000
R55 MemRCol1601 0 0.000000001000
R56 MemRCol1659 0 0.000000001000
R57 MemRCol1718 0 0.000000001000
R58 MemRCol1778 0 0.000000001000
R59 MemRCol1839 0 0.000000001000
R510 MemRCol1901 0 0.000000001000
R511 MemRCol1964 0 0.000000001000
R512 MemRCol2028 0 0.000000001000
R513 MemRCol2093 0 0.000000001000
R514 MemRCol2159 0 0.000000001000
R515 MemRCol2226 0 0.000000001000
R516 MemRCol2294 0 0.000000001000
R517 MemRCol2363 0 0.000000001000
R518 MemRCol2433 0 0.000000001000
R519 MemRCol2504 0 0.000000001000
R520 MemRCol2576 0 0.000000001000
R521 MemRCol2649 0 0.000000001000
R522 MemRCol2723 0 0.000000001000
R523 MemRCol2798 0 0.000000001000
R524 MemRCol2874 0 0.000000001000
R525 MemRCol2951 0 0.000000001000
R526 MemRCol3029 0 0.000000001000
R527 MemRCol3108 0 0.000000001000
R528 MemRCol3188 0 0.000000001000
R529 MemRCol3269 0 0.000000001000
R530 MemRCol3351 0 0.000000001000
R531 MemRCol3434 0 0.000000001000
R532 MemRCol3518 0 0.000000001000
R533 MemRCol3603 0 0.000000001000
R534 MemRCol3689 0 0.000000001000
R535 MemRCol3776 0 0.000000001000
R536 MemRCol3864 0 0.000000001000
R537 MemRCol3953 0 0.000000001000
R538 MemRCol4043 0 0.000000001000
R539 MemRCol4134 0 0.000000001000
R540 MemRCol4226 0 0.000000001000
R541 MemRCol4319 0 0.000000001000
R542 MemRCol4413 0 0.000000001000
R543 MemRCol4508 0 0.000000001000
R544 MemRCol4604 0 0.000000001000
R545 MemRCol4701 0 0.000000001000
R546 MemRCol4799 0 0.000000001000
R547 MemRCol4898 0 0.000000001000
R548 MemRCol4998 0 0.000000001000
R549 MemRCol5099 0 0.000000001000
R550 MemRCol5201 0 0.000000001000

*Spice Directives
.op
*.backanno
.end
