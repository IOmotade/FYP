*mat_array.cir

*Row Voltage Sources
V1 RowC_1 0 0.000000
V3 RowC_2 0 5.000000

*Row Current Sources
I1 I_1 0 -0.000000
I3 I_3 0 -0.000000

*Row 'Ammeter' Resistances
R41 RowC_1 MemRRow4 0.000000001000
R42 RowC_2 MemRRow7 0.000000001000

*Memristor Resistances
