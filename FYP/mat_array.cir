*mat_array.cir

*Voltage Sources
V1 V_1 0 5.000000
V2 V_2 0 5.000000
V3 V_3 0 5.000000
V4 V_4 0 5.000000
V5 V_5 0 5.000000
V6 V_6 0 5.000000
V7 V_7 0 5.000000
V8 V_8 0 5.000000
V9 V_9 0 5.000000
V10 V_10 0 5.000000
V11 V_11 0 5.000000
V12 V_12 0 5.000000
V13 V_13 0 5.000000
V14 V_14 0 5.000000
V15 V_15 0 5.000000
V16 V_16 0 5.000000
V17 V_17 0 5.000000
V18 V_18 0 5.000000
V19 V_19 0 5.000000
V20 V_20 0 5.000000
V21 V_21 0 5.000000
V22 V_22 0 5.000000
V23 V_23 0 5.000000
V24 V_24 0 5.000000
V25 V_25 0 5.000000
V26 V_26 0 5.000000
V27 V_27 0 5.000000
V28 V_28 0 5.000000
V29 V_29 0 5.000000
V30 V_30 0 5.000000
V31 V_31 0 5.000000
V32 V_32 0 5.000000
V33 V_33 0 5.000000
V34 V_34 0 5.000000
V35 V_35 0 5.000000
V36 V_36 0 5.000000
V37 V_37 0 5.000000
V38 V_38 0 5.000000
V39 V_39 0 5.000000
V40 V_40 0 5.000000
V41 V_41 0 5.000000
V42 V_42 0 5.000000
V43 V_43 0 5.000000
V44 V_44 0 5.000000
V45 V_45 0 5.000000
V46 V_46 0 5.000000
V47 V_47 0 5.000000
V48 V_48 0 5.000000
V49 V_49 0 5.000000
V50 V_50 0 5.000000

*Row 'Ammeter' Resistances
R41 V_1 MemRRow11 0.000000001000
R42 V_2 MemRRow21 0.000000001000
R43 V_3 MemRRow31 0.000000001000
R44 V_4 MemRRow41 0.000000001000
R45 V_5 MemRRow51 0.000000001000
R46 V_6 MemRRow61 0.000000001000
R47 V_7 MemRRow71 0.000000001000
R48 V_8 MemRRow81 0.000000001000
R49 V_9 MemRRow91 0.000000001000
R410 V_10 MemRRow101 0.000000001000
R411 V_11 MemRRow111 0.000000001000
R412 V_12 MemRRow121 0.000000001000
R413 V_13 MemRRow131 0.000000001000
R414 V_14 MemRRow141 0.000000001000
R415 V_15 MemRRow151 0.000000001000
R416 V_16 MemRRow161 0.000000001000
R417 V_17 MemRRow171 0.000000001000
R418 V_18 MemRRow181 0.000000001000
R419 V_19 MemRRow191 0.000000001000
R420 V_20 MemRRow201 0.000000001000
R421 V_21 MemRRow211 0.000000001000
R422 V_22 MemRRow221 0.000000001000
R423 V_23 MemRRow231 0.000000001000
R424 V_24 MemRRow241 0.000000001000
R425 V_25 MemRRow251 0.000000001000
R426 V_26 MemRRow261 0.000000001000
R427 V_27 MemRRow271 0.000000001000
R428 V_28 MemRRow281 0.000000001000
R429 V_29 MemRRow291 0.000000001000
R430 V_30 MemRRow301 0.000000001000
R431 V_31 MemRRow311 0.000000001000
R432 V_32 MemRRow321 0.000000001000
R433 V_33 MemRRow331 0.000000001000
R434 V_34 MemRRow341 0.000000001000
R435 V_35 MemRRow351 0.000000001000
R436 V_36 MemRRow361 0.000000001000
R437 V_37 MemRRow371 0.000000001000
R438 V_38 MemRRow381 0.000000001000
R439 V_39 MemRRow391 0.000000001000
R440 V_40 MemRRow401 0.000000001000
R441 V_41 MemRRow411 0.000000001000
R442 V_42 MemRRow421 0.000000001000
R443 V_43 MemRRow431 0.000000001000
R444 V_44 MemRRow441 0.000000001000
R445 V_45 MemRRow451 0.000000001000
R446 V_46 MemRRow461 0.000000001000
R447 V_47 MemRRow471 0.000000001000
R448 V_48 MemRRow481 0.000000001000
R449 V_49 MemRRow491 0.000000001000
R450 V_50 MemRRow501 0.000000001000

*Memristor Resistances
R111 MemRRow11 MemRCol11 10000.000000
R112 MemRRow12 MemRCol12 10000.000000
R113 MemRRow13 MemRCol13 10000.000000
R114 MemRRow14 MemRCol14 10000.000000
R115 MemRRow15 MemRCol15 10000.000000
R116 MemRRow16 MemRCol16 10000.000000
R117 MemRRow17 MemRCol17 10000.000000
R118 MemRRow18 MemRCol18 10000.000000
R119 MemRRow19 MemRCol19 10000.000000
R1110 MemRRow110 MemRCol110 10000.000000
R1111 MemRRow111 MemRCol111 10000.000000
R1112 MemRRow112 MemRCol112 10000.000000
R1113 MemRRow113 MemRCol113 10000.000000
R1114 MemRRow114 MemRCol114 10000.000000
R1115 MemRRow115 MemRCol115 10000.000000
R1116 MemRRow116 MemRCol116 10000.000000
R1117 MemRRow117 MemRCol117 10000.000000
R1118 MemRRow118 MemRCol118 10000.000000
R1119 MemRRow119 MemRCol119 10000.000000
R1120 MemRRow120 MemRCol120 10000.000000
R1121 MemRRow121 MemRCol121 10000.000000
R1122 MemRRow122 MemRCol122 10000.000000
R1123 MemRRow123 MemRCol123 10000.000000
R1124 MemRRow124 MemRCol124 10000.000000
R1125 MemRRow125 MemRCol125 10000.000000
R1126 MemRRow126 MemRCol126 10000.000000
R1127 MemRRow127 MemRCol127 10000.000000
R1128 MemRRow128 MemRCol128 10000.000000
R1129 MemRRow129 MemRCol129 10000.000000
R1130 MemRRow130 MemRCol130 10000.000000
R1131 MemRRow131 MemRCol131 10000.000000
R1132 MemRRow132 MemRCol132 10000.000000
R1133 MemRRow133 MemRCol133 10000.000000
R1134 MemRRow134 MemRCol134 10000.000000
R1135 MemRRow135 MemRCol135 10000.000000
R1136 MemRRow136 MemRCol136 10000.000000
R1137 MemRRow137 MemRCol137 10000.000000
R1138 MemRRow138 MemRCol138 10000.000000
R1139 MemRRow139 MemRCol139 10000.000000
R1140 MemRRow140 MemRCol140 10000.000000
R1141 MemRRow141 MemRCol141 10000.000000
R1142 MemRRow142 MemRCol142 10000.000000
R1143 MemRRow143 MemRCol143 10000.000000
R1144 MemRRow144 MemRCol144 10000.000000
R1145 MemRRow145 MemRCol145 10000.000000
R1146 MemRRow146 MemRCol146 10000.000000
R1147 MemRRow147 MemRCol147 10000.000000
R1148 MemRRow148 MemRCol148 10000.000000
R1149 MemRRow149 MemRCol149 10000.000000
R1150 MemRRow150 MemRCol150 10000.000000
R121 MemRRow21 MemRCol21 10000.000000
R122 MemRRow22 MemRCol22 10000.000000
R123 MemRRow23 MemRCol23 10000.000000
R124 MemRRow24 MemRCol24 10000.000000
R125 MemRRow25 MemRCol25 10000.000000
R126 MemRRow26 MemRCol26 10000.000000
R127 MemRRow27 MemRCol27 10000.000000
R128 MemRRow28 MemRCol28 10000.000000
R129 MemRRow29 MemRCol29 10000.000000
R1210 MemRRow210 MemRCol210 10000.000000
R1211 MemRRow211 MemRCol211 10000.000000
R1212 MemRRow212 MemRCol212 10000.000000
R1213 MemRRow213 MemRCol213 10000.000000
R1214 MemRRow214 MemRCol214 10000.000000
R1215 MemRRow215 MemRCol215 10000.000000
R1216 MemRRow216 MemRCol216 10000.000000
R1217 MemRRow217 MemRCol217 10000.000000
R1218 MemRRow218 MemRCol218 10000.000000
R1219 MemRRow219 MemRCol219 10000.000000
R1220 MemRRow220 MemRCol220 10000.000000
R1221 MemRRow221 MemRCol221 10000.000000
R1222 MemRRow222 MemRCol222 10000.000000
R1223 MemRRow223 MemRCol223 10000.000000
R1224 MemRRow224 MemRCol224 10000.000000
R1225 MemRRow225 MemRCol225 10000.000000
R1226 MemRRow226 MemRCol226 10000.000000
R1227 MemRRow227 MemRCol227 10000.000000
R1228 MemRRow228 MemRCol228 10000.000000
R1229 MemRRow229 MemRCol229 10000.000000
R1230 MemRRow230 MemRCol230 10000.000000
R1231 MemRRow231 MemRCol231 10000.000000
R1232 MemRRow232 MemRCol232 10000.000000
R1233 MemRRow233 MemRCol233 10000.000000
R1234 MemRRow234 MemRCol234 10000.000000
R1235 MemRRow235 MemRCol235 10000.000000
R1236 MemRRow236 MemRCol236 10000.000000
R1237 MemRRow237 MemRCol237 10000.000000
R1238 MemRRow238 MemRCol238 10000.000000
R1239 MemRRow239 MemRCol239 10000.000000
R1240 MemRRow240 MemRCol240 10000.000000
R1241 MemRRow241 MemRCol241 10000.000000
R1242 MemRRow242 MemRCol242 10000.000000
R1243 MemRRow243 MemRCol243 10000.000000
R1244 MemRRow244 MemRCol244 10000.000000
R1245 MemRRow245 MemRCol245 10000.000000
R1246 MemRRow246 MemRCol246 10000.000000
R1247 MemRRow247 MemRCol247 10000.000000
R1248 MemRRow248 MemRCol248 10000.000000
R1249 MemRRow249 MemRCol249 10000.000000
R1250 MemRRow250 MemRCol250 10000.000000
R131 MemRRow31 MemRCol31 10000.000000
R132 MemRRow32 MemRCol32 10000.000000
R133 MemRRow33 MemRCol33 10000.000000
R134 MemRRow34 MemRCol34 10000.000000
R135 MemRRow35 MemRCol35 10000.000000
R136 MemRRow36 MemRCol36 10000.000000
R137 MemRRow37 MemRCol37 10000.000000
R138 MemRRow38 MemRCol38 10000.000000
R139 MemRRow39 MemRCol39 10000.000000
R1310 MemRRow310 MemRCol310 10000.000000
R1311 MemRRow311 MemRCol311 10000.000000
R1312 MemRRow312 MemRCol312 10000.000000
R1313 MemRRow313 MemRCol313 10000.000000
R1314 MemRRow314 MemRCol314 10000.000000
R1315 MemRRow315 MemRCol315 10000.000000
R1316 MemRRow316 MemRCol316 10000.000000
R1317 MemRRow317 MemRCol317 10000.000000
R1318 MemRRow318 MemRCol318 10000.000000
R1319 MemRRow319 MemRCol319 10000.000000
R1320 MemRRow320 MemRCol320 10000.000000
R1321 MemRRow321 MemRCol321 10000.000000
R1322 MemRRow322 MemRCol322 10000.000000
R1323 MemRRow323 MemRCol323 10000.000000
R1324 MemRRow324 MemRCol324 10000.000000
R1325 MemRRow325 MemRCol325 10000.000000
R1326 MemRRow326 MemRCol326 10000.000000
R1327 MemRRow327 MemRCol327 10000.000000
R1328 MemRRow328 MemRCol328 10000.000000
R1329 MemRRow329 MemRCol329 10000.000000
R1330 MemRRow330 MemRCol330 10000.000000
R1331 MemRRow331 MemRCol331 10000.000000
R1332 MemRRow332 MemRCol332 10000.000000
R1333 MemRRow333 MemRCol333 10000.000000
R1334 MemRRow334 MemRCol334 10000.000000
R1335 MemRRow335 MemRCol335 10000.000000
R1336 MemRRow336 MemRCol336 10000.000000
R1337 MemRRow337 MemRCol337 10000.000000
R1338 MemRRow338 MemRCol338 10000.000000
R1339 MemRRow339 MemRCol339 10000.000000
R1340 MemRRow340 MemRCol340 10000.000000
R1341 MemRRow341 MemRCol341 10000.000000
R1342 MemRRow342 MemRCol342 10000.000000
R1343 MemRRow343 MemRCol343 10000.000000
R1344 MemRRow344 MemRCol344 10000.000000
R1345 MemRRow345 MemRCol345 10000.000000
R1346 MemRRow346 MemRCol346 10000.000000
R1347 MemRRow347 MemRCol347 10000.000000
R1348 MemRRow348 MemRCol348 10000.000000
R1349 MemRRow349 MemRCol349 10000.000000
R1350 MemRRow350 MemRCol350 10000.000000
R141 MemRRow41 MemRCol41 10000.000000
R142 MemRRow42 MemRCol42 10000.000000
R143 MemRRow43 MemRCol43 10000.000000
R144 MemRRow44 MemRCol44 10000.000000
R145 MemRRow45 MemRCol45 10000.000000
R146 MemRRow46 MemRCol46 10000.000000
R147 MemRRow47 MemRCol47 10000.000000
R148 MemRRow48 MemRCol48 10000.000000
R149 MemRRow49 MemRCol49 10000.000000
R1410 MemRRow410 MemRCol410 10000.000000
R1411 MemRRow411 MemRCol411 10000.000000
R1412 MemRRow412 MemRCol412 10000.000000
R1413 MemRRow413 MemRCol413 10000.000000
R1414 MemRRow414 MemRCol414 10000.000000
R1415 MemRRow415 MemRCol415 10000.000000
R1416 MemRRow416 MemRCol416 10000.000000
R1417 MemRRow417 MemRCol417 10000.000000
R1418 MemRRow418 MemRCol418 10000.000000
R1419 MemRRow419 MemRCol419 10000.000000
R1420 MemRRow420 MemRCol420 10000.000000
R1421 MemRRow421 MemRCol421 10000.000000
R1422 MemRRow422 MemRCol422 10000.000000
R1423 MemRRow423 MemRCol423 10000.000000
R1424 MemRRow424 MemRCol424 10000.000000
R1425 MemRRow425 MemRCol425 10000.000000
R1426 MemRRow426 MemRCol426 10000.000000
R1427 MemRRow427 MemRCol427 10000.000000
R1428 MemRRow428 MemRCol428 10000.000000
R1429 MemRRow429 MemRCol429 10000.000000
R1430 MemRRow430 MemRCol430 10000.000000
R1431 MemRRow431 MemRCol431 10000.000000
R1432 MemRRow432 MemRCol432 10000.000000
R1433 MemRRow433 MemRCol433 10000.000000
R1434 MemRRow434 MemRCol434 10000.000000
R1435 MemRRow435 MemRCol435 10000.000000
R1436 MemRRow436 MemRCol436 10000.000000
R1437 MemRRow437 MemRCol437 10000.000000
R1438 MemRRow438 MemRCol438 10000.000000
R1439 MemRRow439 MemRCol439 10000.000000
R1440 MemRRow440 MemRCol440 10000.000000
R1441 MemRRow441 MemRCol441 10000.000000
R1442 MemRRow442 MemRCol442 10000.000000
R1443 MemRRow443 MemRCol443 10000.000000
R1444 MemRRow444 MemRCol444 10000.000000
R1445 MemRRow445 MemRCol445 10000.000000
R1446 MemRRow446 MemRCol446 10000.000000
R1447 MemRRow447 MemRCol447 10000.000000
R1448 MemRRow448 MemRCol448 10000.000000
R1449 MemRRow449 MemRCol449 10000.000000
R1450 MemRRow450 MemRCol450 10000.000000
R151 MemRRow51 MemRCol51 10000.000000
R152 MemRRow52 MemRCol52 10000.000000
R153 MemRRow53 MemRCol53 10000.000000
R154 MemRRow54 MemRCol54 10000.000000
R155 MemRRow55 MemRCol55 10000.000000
R156 MemRRow56 MemRCol56 10000.000000
R157 MemRRow57 MemRCol57 10000.000000
R158 MemRRow58 MemRCol58 10000.000000
R159 MemRRow59 MemRCol59 10000.000000
R1510 MemRRow510 MemRCol510 10000.000000
R1511 MemRRow511 MemRCol511 10000.000000
R1512 MemRRow512 MemRCol512 10000.000000
R1513 MemRRow513 MemRCol513 10000.000000
R1514 MemRRow514 MemRCol514 10000.000000
R1515 MemRRow515 MemRCol515 10000.000000
R1516 MemRRow516 MemRCol516 10000.000000
R1517 MemRRow517 MemRCol517 10000.000000
R1518 MemRRow518 MemRCol518 10000.000000
R1519 MemRRow519 MemRCol519 10000.000000
R1520 MemRRow520 MemRCol520 10000.000000
R1521 MemRRow521 MemRCol521 10000.000000
R1522 MemRRow522 MemRCol522 10000.000000
R1523 MemRRow523 MemRCol523 10000.000000
R1524 MemRRow524 MemRCol524 10000.000000
R1525 MemRRow525 MemRCol525 10000.000000
R1526 MemRRow526 MemRCol526 10000.000000
R1527 MemRRow527 MemRCol527 10000.000000
R1528 MemRRow528 MemRCol528 10000.000000
R1529 MemRRow529 MemRCol529 10000.000000
R1530 MemRRow530 MemRCol530 10000.000000
R1531 MemRRow531 MemRCol531 10000.000000
R1532 MemRRow532 MemRCol532 10000.000000
R1533 MemRRow533 MemRCol533 10000.000000
R1534 MemRRow534 MemRCol534 10000.000000
R1535 MemRRow535 MemRCol535 10000.000000
R1536 MemRRow536 MemRCol536 10000.000000
R1537 MemRRow537 MemRCol537 10000.000000
R1538 MemRRow538 MemRCol538 10000.000000
R1539 MemRRow539 MemRCol539 10000.000000
R1540 MemRRow540 MemRCol540 10000.000000
R1541 MemRRow541 MemRCol541 10000.000000
R1542 MemRRow542 MemRCol542 10000.000000
R1543 MemRRow543 MemRCol543 10000.000000
R1544 MemRRow544 MemRCol544 10000.000000
R1545 MemRRow545 MemRCol545 10000.000000
R1546 MemRRow546 MemRCol546 10000.000000
R1547 MemRRow547 MemRCol547 10000.000000
R1548 MemRRow548 MemRCol548 10000.000000
R1549 MemRRow549 MemRCol549 10000.000000
R1550 MemRRow550 MemRCol550 10000.000000
R161 MemRRow61 MemRCol61 10000.000000
R162 MemRRow62 MemRCol62 10000.000000
R163 MemRRow63 MemRCol63 10000.000000
R164 MemRRow64 MemRCol64 10000.000000
R165 MemRRow65 MemRCol65 10000.000000
R166 MemRRow66 MemRCol66 10000.000000
R167 MemRRow67 MemRCol67 10000.000000
R168 MemRRow68 MemRCol68 10000.000000
R169 MemRRow69 MemRCol69 10000.000000
R1610 MemRRow610 MemRCol610 10000.000000
R1611 MemRRow611 MemRCol611 10000.000000
R1612 MemRRow612 MemRCol612 10000.000000
R1613 MemRRow613 MemRCol613 10000.000000
R1614 MemRRow614 MemRCol614 10000.000000
R1615 MemRRow615 MemRCol615 10000.000000
R1616 MemRRow616 MemRCol616 10000.000000
R1617 MemRRow617 MemRCol617 10000.000000
R1618 MemRRow618 MemRCol618 10000.000000
R1619 MemRRow619 MemRCol619 10000.000000
R1620 MemRRow620 MemRCol620 10000.000000
R1621 MemRRow621 MemRCol621 10000.000000
R1622 MemRRow622 MemRCol622 10000.000000
R1623 MemRRow623 MemRCol623 10000.000000
R1624 MemRRow624 MemRCol624 10000.000000
R1625 MemRRow625 MemRCol625 10000.000000
R1626 MemRRow626 MemRCol626 10000.000000
R1627 MemRRow627 MemRCol627 10000.000000
R1628 MemRRow628 MemRCol628 10000.000000
R1629 MemRRow629 MemRCol629 10000.000000
R1630 MemRRow630 MemRCol630 10000.000000
R1631 MemRRow631 MemRCol631 10000.000000
R1632 MemRRow632 MemRCol632 10000.000000
R1633 MemRRow633 MemRCol633 10000.000000
R1634 MemRRow634 MemRCol634 10000.000000
R1635 MemRRow635 MemRCol635 10000.000000
R1636 MemRRow636 MemRCol636 10000.000000
R1637 MemRRow637 MemRCol637 10000.000000
R1638 MemRRow638 MemRCol638 10000.000000
R1639 MemRRow639 MemRCol639 10000.000000
R1640 MemRRow640 MemRCol640 10000.000000
R1641 MemRRow641 MemRCol641 10000.000000
R1642 MemRRow642 MemRCol642 10000.000000
R1643 MemRRow643 MemRCol643 10000.000000
R1644 MemRRow644 MemRCol644 10000.000000
R1645 MemRRow645 MemRCol645 10000.000000
R1646 MemRRow646 MemRCol646 10000.000000
R1647 MemRRow647 MemRCol647 10000.000000
R1648 MemRRow648 MemRCol648 10000.000000
R1649 MemRRow649 MemRCol649 10000.000000
R1650 MemRRow650 MemRCol650 10000.000000
R171 MemRRow71 MemRCol71 10000.000000
R172 MemRRow72 MemRCol72 10000.000000
R173 MemRRow73 MemRCol73 10000.000000
R174 MemRRow74 MemRCol74 10000.000000
R175 MemRRow75 MemRCol75 10000.000000
R176 MemRRow76 MemRCol76 10000.000000
R177 MemRRow77 MemRCol77 10000.000000
R178 MemRRow78 MemRCol78 10000.000000
R179 MemRRow79 MemRCol79 10000.000000
R1710 MemRRow710 MemRCol710 10000.000000
R1711 MemRRow711 MemRCol711 10000.000000
R1712 MemRRow712 MemRCol712 10000.000000
R1713 MemRRow713 MemRCol713 10000.000000
R1714 MemRRow714 MemRCol714 10000.000000
R1715 MemRRow715 MemRCol715 10000.000000
R1716 MemRRow716 MemRCol716 10000.000000
R1717 MemRRow717 MemRCol717 10000.000000
R1718 MemRRow718 MemRCol718 10000.000000
R1719 MemRRow719 MemRCol719 10000.000000
R1720 MemRRow720 MemRCol720 10000.000000
R1721 MemRRow721 MemRCol721 10000.000000
R1722 MemRRow722 MemRCol722 10000.000000
R1723 MemRRow723 MemRCol723 10000.000000
R1724 MemRRow724 MemRCol724 10000.000000
R1725 MemRRow725 MemRCol725 10000.000000
R1726 MemRRow726 MemRCol726 10000.000000
R1727 MemRRow727 MemRCol727 10000.000000
R1728 MemRRow728 MemRCol728 10000.000000
R1729 MemRRow729 MemRCol729 10000.000000
R1730 MemRRow730 MemRCol730 10000.000000
R1731 MemRRow731 MemRCol731 10000.000000
R1732 MemRRow732 MemRCol732 10000.000000
R1733 MemRRow733 MemRCol733 10000.000000
R1734 MemRRow734 MemRCol734 10000.000000
R1735 MemRRow735 MemRCol735 10000.000000
R1736 MemRRow736 MemRCol736 10000.000000
R1737 MemRRow737 MemRCol737 10000.000000
R1738 MemRRow738 MemRCol738 10000.000000
R1739 MemRRow739 MemRCol739 10000.000000
R1740 MemRRow740 MemRCol740 10000.000000
R1741 MemRRow741 MemRCol741 10000.000000
R1742 MemRRow742 MemRCol742 10000.000000
R1743 MemRRow743 MemRCol743 10000.000000
R1744 MemRRow744 MemRCol744 10000.000000
R1745 MemRRow745 MemRCol745 10000.000000
R1746 MemRRow746 MemRCol746 10000.000000
R1747 MemRRow747 MemRCol747 10000.000000
R1748 MemRRow748 MemRCol748 10000.000000
R1749 MemRRow749 MemRCol749 10000.000000
R1750 MemRRow750 MemRCol750 10000.000000
R181 MemRRow81 MemRCol81 10000.000000
R182 MemRRow82 MemRCol82 10000.000000
R183 MemRRow83 MemRCol83 10000.000000
R184 MemRRow84 MemRCol84 10000.000000
R185 MemRRow85 MemRCol85 10000.000000
R186 MemRRow86 MemRCol86 10000.000000
R187 MemRRow87 MemRCol87 10000.000000
R188 MemRRow88 MemRCol88 10000.000000
R189 MemRRow89 MemRCol89 10000.000000
R1810 MemRRow810 MemRCol810 10000.000000
R1811 MemRRow811 MemRCol811 10000.000000
R1812 MemRRow812 MemRCol812 10000.000000
R1813 MemRRow813 MemRCol813 10000.000000
R1814 MemRRow814 MemRCol814 10000.000000
R1815 MemRRow815 MemRCol815 10000.000000
R1816 MemRRow816 MemRCol816 10000.000000
R1817 MemRRow817 MemRCol817 10000.000000
R1818 MemRRow818 MemRCol818 10000.000000
R1819 MemRRow819 MemRCol819 10000.000000
R1820 MemRRow820 MemRCol820 10000.000000
R1821 MemRRow821 MemRCol821 10000.000000
R1822 MemRRow822 MemRCol822 10000.000000
R1823 MemRRow823 MemRCol823 10000.000000
R1824 MemRRow824 MemRCol824 10000.000000
R1825 MemRRow825 MemRCol825 10000.000000
R1826 MemRRow826 MemRCol826 10000.000000
R1827 MemRRow827 MemRCol827 10000.000000
R1828 MemRRow828 MemRCol828 10000.000000
R1829 MemRRow829 MemRCol829 10000.000000
R1830 MemRRow830 MemRCol830 10000.000000
R1831 MemRRow831 MemRCol831 10000.000000
R1832 MemRRow832 MemRCol832 10000.000000
R1833 MemRRow833 MemRCol833 10000.000000
R1834 MemRRow834 MemRCol834 10000.000000
R1835 MemRRow835 MemRCol835 10000.000000
R1836 MemRRow836 MemRCol836 10000.000000
R1837 MemRRow837 MemRCol837 10000.000000
R1838 MemRRow838 MemRCol838 10000.000000
R1839 MemRRow839 MemRCol839 10000.000000
R1840 MemRRow840 MemRCol840 10000.000000
R1841 MemRRow841 MemRCol841 10000.000000
R1842 MemRRow842 MemRCol842 10000.000000
R1843 MemRRow843 MemRCol843 10000.000000
R1844 MemRRow844 MemRCol844 10000.000000
R1845 MemRRow845 MemRCol845 10000.000000
R1846 MemRRow846 MemRCol846 10000.000000
R1847 MemRRow847 MemRCol847 10000.000000
R1848 MemRRow848 MemRCol848 10000.000000
R1849 MemRRow849 MemRCol849 10000.000000
R1850 MemRRow850 MemRCol850 10000.000000
R191 MemRRow91 MemRCol91 10000.000000
R192 MemRRow92 MemRCol92 10000.000000
R193 MemRRow93 MemRCol93 10000.000000
R194 MemRRow94 MemRCol94 10000.000000
R195 MemRRow95 MemRCol95 10000.000000
R196 MemRRow96 MemRCol96 10000.000000
R197 MemRRow97 MemRCol97 10000.000000
R198 MemRRow98 MemRCol98 10000.000000
R199 MemRRow99 MemRCol99 10000.000000
R1910 MemRRow910 MemRCol910 10000.000000
R1911 MemRRow911 MemRCol911 10000.000000
R1912 MemRRow912 MemRCol912 10000.000000
R1913 MemRRow913 MemRCol913 10000.000000
R1914 MemRRow914 MemRCol914 10000.000000
R1915 MemRRow915 MemRCol915 10000.000000
R1916 MemRRow916 MemRCol916 10000.000000
R1917 MemRRow917 MemRCol917 10000.000000
R1918 MemRRow918 MemRCol918 10000.000000
R1919 MemRRow919 MemRCol919 10000.000000
R1920 MemRRow920 MemRCol920 10000.000000
R1921 MemRRow921 MemRCol921 10000.000000
R1922 MemRRow922 MemRCol922 10000.000000
R1923 MemRRow923 MemRCol923 10000.000000
R1924 MemRRow924 MemRCol924 10000.000000
R1925 MemRRow925 MemRCol925 10000.000000
R1926 MemRRow926 MemRCol926 10000.000000
R1927 MemRRow927 MemRCol927 10000.000000
R1928 MemRRow928 MemRCol928 10000.000000
R1929 MemRRow929 MemRCol929 10000.000000
R1930 MemRRow930 MemRCol930 10000.000000
R1931 MemRRow931 MemRCol931 10000.000000
R1932 MemRRow932 MemRCol932 10000.000000
R1933 MemRRow933 MemRCol933 10000.000000
R1934 MemRRow934 MemRCol934 10000.000000
R1935 MemRRow935 MemRCol935 10000.000000
R1936 MemRRow936 MemRCol936 10000.000000
R1937 MemRRow937 MemRCol937 10000.000000
R1938 MemRRow938 MemRCol938 10000.000000
R1939 MemRRow939 MemRCol939 10000.000000
R1940 MemRRow940 MemRCol940 10000.000000
R1941 MemRRow941 MemRCol941 10000.000000
R1942 MemRRow942 MemRCol942 10000.000000
R1943 MemRRow943 MemRCol943 10000.000000
R1944 MemRRow944 MemRCol944 10000.000000
R1945 MemRRow945 MemRCol945 10000.000000
R1946 MemRRow946 MemRCol946 10000.000000
R1947 MemRRow947 MemRCol947 10000.000000
R1948 MemRRow948 MemRCol948 10000.000000
R1949 MemRRow949 MemRCol949 10000.000000
R1950 MemRRow950 MemRCol950 10000.000000
R1101 MemRRow101 MemRCol101 10000.000000
R1102 MemRRow102 MemRCol102 10000.000000
R1103 MemRRow103 MemRCol103 10000.000000
R1104 MemRRow104 MemRCol104 10000.000000
R1105 MemRRow105 MemRCol105 10000.000000
R1106 MemRRow106 MemRCol106 10000.000000
R1107 MemRRow107 MemRCol107 10000.000000
R1108 MemRRow108 MemRCol108 10000.000000
R1109 MemRRow109 MemRCol109 10000.000000
R11010 MemRRow1010 MemRCol1010 10000.000000
R11011 MemRRow1011 MemRCol1011 10000.000000
R11012 MemRRow1012 MemRCol1012 10000.000000
R11013 MemRRow1013 MemRCol1013 10000.000000
R11014 MemRRow1014 MemRCol1014 10000.000000
R11015 MemRRow1015 MemRCol1015 10000.000000
R11016 MemRRow1016 MemRCol1016 10000.000000
R11017 MemRRow1017 MemRCol1017 10000.000000
R11018 MemRRow1018 MemRCol1018 10000.000000
R11019 MemRRow1019 MemRCol1019 10000.000000
R11020 MemRRow1020 MemRCol1020 10000.000000
R11021 MemRRow1021 MemRCol1021 10000.000000
R11022 MemRRow1022 MemRCol1022 10000.000000
R11023 MemRRow1023 MemRCol1023 10000.000000
R11024 MemRRow1024 MemRCol1024 10000.000000
R11025 MemRRow1025 MemRCol1025 10000.000000
R11026 MemRRow1026 MemRCol1026 10000.000000
R11027 MemRRow1027 MemRCol1027 10000.000000
R11028 MemRRow1028 MemRCol1028 10000.000000
R11029 MemRRow1029 MemRCol1029 10000.000000
R11030 MemRRow1030 MemRCol1030 10000.000000
R11031 MemRRow1031 MemRCol1031 10000.000000
R11032 MemRRow1032 MemRCol1032 10000.000000
R11033 MemRRow1033 MemRCol1033 10000.000000
R11034 MemRRow1034 MemRCol1034 10000.000000
R11035 MemRRow1035 MemRCol1035 10000.000000
R11036 MemRRow1036 MemRCol1036 10000.000000
R11037 MemRRow1037 MemRCol1037 10000.000000
R11038 MemRRow1038 MemRCol1038 10000.000000
R11039 MemRRow1039 MemRCol1039 10000.000000
R11040 MemRRow1040 MemRCol1040 10000.000000
R11041 MemRRow1041 MemRCol1041 10000.000000
R11042 MemRRow1042 MemRCol1042 10000.000000
R11043 MemRRow1043 MemRCol1043 10000.000000
R11044 MemRRow1044 MemRCol1044 10000.000000
R11045 MemRRow1045 MemRCol1045 10000.000000
R11046 MemRRow1046 MemRCol1046 10000.000000
R11047 MemRRow1047 MemRCol1047 10000.000000
R11048 MemRRow1048 MemRCol1048 10000.000000
R11049 MemRRow1049 MemRCol1049 10000.000000
R11050 MemRRow1050 MemRCol1050 10000.000000
R1111 MemRRow111 MemRCol111 10000.000000
R1112 MemRRow112 MemRCol112 10000.000000
R1113 MemRRow113 MemRCol113 10000.000000
R1114 MemRRow114 MemRCol114 10000.000000
R1115 MemRRow115 MemRCol115 10000.000000
R1116 MemRRow116 MemRCol116 10000.000000
R1117 MemRRow117 MemRCol117 10000.000000
R1118 MemRRow118 MemRCol118 10000.000000
R1119 MemRRow119 MemRCol119 10000.000000
R11110 MemRRow1110 MemRCol1110 10000.000000
R11111 MemRRow1111 MemRCol1111 10000.000000
R11112 MemRRow1112 MemRCol1112 10000.000000
R11113 MemRRow1113 MemRCol1113 10000.000000
R11114 MemRRow1114 MemRCol1114 10000.000000
R11115 MemRRow1115 MemRCol1115 10000.000000
R11116 MemRRow1116 MemRCol1116 10000.000000
R11117 MemRRow1117 MemRCol1117 10000.000000
R11118 MemRRow1118 MemRCol1118 10000.000000
R11119 MemRRow1119 MemRCol1119 10000.000000
R11120 MemRRow1120 MemRCol1120 10000.000000
R11121 MemRRow1121 MemRCol1121 10000.000000
R11122 MemRRow1122 MemRCol1122 10000.000000
R11123 MemRRow1123 MemRCol1123 10000.000000
R11124 MemRRow1124 MemRCol1124 10000.000000
R11125 MemRRow1125 MemRCol1125 10000.000000
R11126 MemRRow1126 MemRCol1126 10000.000000
R11127 MemRRow1127 MemRCol1127 10000.000000
R11128 MemRRow1128 MemRCol1128 10000.000000
R11129 MemRRow1129 MemRCol1129 10000.000000
R11130 MemRRow1130 MemRCol1130 10000.000000
R11131 MemRRow1131 MemRCol1131 10000.000000
R11132 MemRRow1132 MemRCol1132 10000.000000
R11133 MemRRow1133 MemRCol1133 10000.000000
R11134 MemRRow1134 MemRCol1134 10000.000000
R11135 MemRRow1135 MemRCol1135 10000.000000
R11136 MemRRow1136 MemRCol1136 10000.000000
R11137 MemRRow1137 MemRCol1137 10000.000000
R11138 MemRRow1138 MemRCol1138 10000.000000
R11139 MemRRow1139 MemRCol1139 10000.000000
R11140 MemRRow1140 MemRCol1140 10000.000000
R11141 MemRRow1141 MemRCol1141 10000.000000
R11142 MemRRow1142 MemRCol1142 10000.000000
R11143 MemRRow1143 MemRCol1143 10000.000000
R11144 MemRRow1144 MemRCol1144 10000.000000
R11145 MemRRow1145 MemRCol1145 10000.000000
R11146 MemRRow1146 MemRCol1146 10000.000000
R11147 MemRRow1147 MemRCol1147 10000.000000
R11148 MemRRow1148 MemRCol1148 10000.000000
R11149 MemRRow1149 MemRCol1149 10000.000000
R11150 MemRRow1150 MemRCol1150 10000.000000
R1121 MemRRow121 MemRCol121 10000.000000
R1122 MemRRow122 MemRCol122 10000.000000
R1123 MemRRow123 MemRCol123 10000.000000
R1124 MemRRow124 MemRCol124 10000.000000
R1125 MemRRow125 MemRCol125 10000.000000
R1126 MemRRow126 MemRCol126 10000.000000
R1127 MemRRow127 MemRCol127 10000.000000
R1128 MemRRow128 MemRCol128 10000.000000
R1129 MemRRow129 MemRCol129 10000.000000
R11210 MemRRow1210 MemRCol1210 10000.000000
R11211 MemRRow1211 MemRCol1211 10000.000000
R11212 MemRRow1212 MemRCol1212 10000.000000
R11213 MemRRow1213 MemRCol1213 10000.000000
R11214 MemRRow1214 MemRCol1214 10000.000000
R11215 MemRRow1215 MemRCol1215 10000.000000
R11216 MemRRow1216 MemRCol1216 10000.000000
R11217 MemRRow1217 MemRCol1217 10000.000000
R11218 MemRRow1218 MemRCol1218 10000.000000
R11219 MemRRow1219 MemRCol1219 10000.000000
R11220 MemRRow1220 MemRCol1220 10000.000000
R11221 MemRRow1221 MemRCol1221 10000.000000
R11222 MemRRow1222 MemRCol1222 10000.000000
R11223 MemRRow1223 MemRCol1223 10000.000000
R11224 MemRRow1224 MemRCol1224 10000.000000
R11225 MemRRow1225 MemRCol1225 10000.000000
R11226 MemRRow1226 MemRCol1226 10000.000000
R11227 MemRRow1227 MemRCol1227 10000.000000
R11228 MemRRow1228 MemRCol1228 10000.000000
R11229 MemRRow1229 MemRCol1229 10000.000000
R11230 MemRRow1230 MemRCol1230 10000.000000
R11231 MemRRow1231 MemRCol1231 10000.000000
R11232 MemRRow1232 MemRCol1232 10000.000000
R11233 MemRRow1233 MemRCol1233 10000.000000
R11234 MemRRow1234 MemRCol1234 10000.000000
R11235 MemRRow1235 MemRCol1235 10000.000000
R11236 MemRRow1236 MemRCol1236 10000.000000
R11237 MemRRow1237 MemRCol1237 10000.000000
R11238 MemRRow1238 MemRCol1238 10000.000000
R11239 MemRRow1239 MemRCol1239 10000.000000
R11240 MemRRow1240 MemRCol1240 10000.000000
R11241 MemRRow1241 MemRCol1241 10000.000000
R11242 MemRRow1242 MemRCol1242 10000.000000
R11243 MemRRow1243 MemRCol1243 10000.000000
R11244 MemRRow1244 MemRCol1244 10000.000000
R11245 MemRRow1245 MemRCol1245 10000.000000
R11246 MemRRow1246 MemRCol1246 10000.000000
R11247 MemRRow1247 MemRCol1247 10000.000000
R11248 MemRRow1248 MemRCol1248 10000.000000
R11249 MemRRow1249 MemRCol1249 10000.000000
R11250 MemRRow1250 MemRCol1250 10000.000000
R1131 MemRRow131 MemRCol131 10000.000000
R1132 MemRRow132 MemRCol132 10000.000000
R1133 MemRRow133 MemRCol133 10000.000000
R1134 MemRRow134 MemRCol134 10000.000000
R1135 MemRRow135 MemRCol135 10000.000000
R1136 MemRRow136 MemRCol136 10000.000000
R1137 MemRRow137 MemRCol137 10000.000000
R1138 MemRRow138 MemRCol138 10000.000000
R1139 MemRRow139 MemRCol139 10000.000000
R11310 MemRRow1310 MemRCol1310 10000.000000
R11311 MemRRow1311 MemRCol1311 10000.000000
R11312 MemRRow1312 MemRCol1312 10000.000000
R11313 MemRRow1313 MemRCol1313 10000.000000
R11314 MemRRow1314 MemRCol1314 10000.000000
R11315 MemRRow1315 MemRCol1315 10000.000000
R11316 MemRRow1316 MemRCol1316 10000.000000
R11317 MemRRow1317 MemRCol1317 10000.000000
R11318 MemRRow1318 MemRCol1318 10000.000000
R11319 MemRRow1319 MemRCol1319 10000.000000
R11320 MemRRow1320 MemRCol1320 10000.000000
R11321 MemRRow1321 MemRCol1321 10000.000000
R11322 MemRRow1322 MemRCol1322 10000.000000
R11323 MemRRow1323 MemRCol1323 10000.000000
R11324 MemRRow1324 MemRCol1324 10000.000000
R11325 MemRRow1325 MemRCol1325 10000.000000
R11326 MemRRow1326 MemRCol1326 10000.000000
R11327 MemRRow1327 MemRCol1327 10000.000000
R11328 MemRRow1328 MemRCol1328 10000.000000
R11329 MemRRow1329 MemRCol1329 10000.000000
R11330 MemRRow1330 MemRCol1330 10000.000000
R11331 MemRRow1331 MemRCol1331 10000.000000
R11332 MemRRow1332 MemRCol1332 10000.000000
R11333 MemRRow1333 MemRCol1333 10000.000000
R11334 MemRRow1334 MemRCol1334 10000.000000
R11335 MemRRow1335 MemRCol1335 10000.000000
R11336 MemRRow1336 MemRCol1336 10000.000000
R11337 MemRRow1337 MemRCol1337 10000.000000
R11338 MemRRow1338 MemRCol1338 10000.000000
R11339 MemRRow1339 MemRCol1339 10000.000000
R11340 MemRRow1340 MemRCol1340 10000.000000
R11341 MemRRow1341 MemRCol1341 10000.000000
R11342 MemRRow1342 MemRCol1342 10000.000000
R11343 MemRRow1343 MemRCol1343 10000.000000
R11344 MemRRow1344 MemRCol1344 10000.000000
R11345 MemRRow1345 MemRCol1345 10000.000000
R11346 MemRRow1346 MemRCol1346 10000.000000
R11347 MemRRow1347 MemRCol1347 10000.000000
R11348 MemRRow1348 MemRCol1348 10000.000000
R11349 MemRRow1349 MemRCol1349 10000.000000
R11350 MemRRow1350 MemRCol1350 10000.000000
R1141 MemRRow141 MemRCol141 10000.000000
R1142 MemRRow142 MemRCol142 10000.000000
R1143 MemRRow143 MemRCol143 10000.000000
R1144 MemRRow144 MemRCol144 10000.000000
R1145 MemRRow145 MemRCol145 10000.000000
R1146 MemRRow146 MemRCol146 10000.000000
R1147 MemRRow147 MemRCol147 10000.000000
R1148 MemRRow148 MemRCol148 10000.000000
R1149 MemRRow149 MemRCol149 10000.000000
R11410 MemRRow1410 MemRCol1410 10000.000000
R11411 MemRRow1411 MemRCol1411 10000.000000
R11412 MemRRow1412 MemRCol1412 10000.000000
R11413 MemRRow1413 MemRCol1413 10000.000000
R11414 MemRRow1414 MemRCol1414 10000.000000
R11415 MemRRow1415 MemRCol1415 10000.000000
R11416 MemRRow1416 MemRCol1416 10000.000000
R11417 MemRRow1417 MemRCol1417 10000.000000
R11418 MemRRow1418 MemRCol1418 10000.000000
R11419 MemRRow1419 MemRCol1419 10000.000000
R11420 MemRRow1420 MemRCol1420 10000.000000
R11421 MemRRow1421 MemRCol1421 10000.000000
R11422 MemRRow1422 MemRCol1422 10000.000000
R11423 MemRRow1423 MemRCol1423 10000.000000
R11424 MemRRow1424 MemRCol1424 10000.000000
R11425 MemRRow1425 MemRCol1425 10000.000000
R11426 MemRRow1426 MemRCol1426 10000.000000
R11427 MemRRow1427 MemRCol1427 10000.000000
R11428 MemRRow1428 MemRCol1428 10000.000000
R11429 MemRRow1429 MemRCol1429 10000.000000
R11430 MemRRow1430 MemRCol1430 10000.000000
R11431 MemRRow1431 MemRCol1431 10000.000000
R11432 MemRRow1432 MemRCol1432 10000.000000
R11433 MemRRow1433 MemRCol1433 10000.000000
R11434 MemRRow1434 MemRCol1434 10000.000000
R11435 MemRRow1435 MemRCol1435 10000.000000
R11436 MemRRow1436 MemRCol1436 10000.000000
R11437 MemRRow1437 MemRCol1437 10000.000000
R11438 MemRRow1438 MemRCol1438 10000.000000
R11439 MemRRow1439 MemRCol1439 10000.000000
R11440 MemRRow1440 MemRCol1440 10000.000000
R11441 MemRRow1441 MemRCol1441 10000.000000
R11442 MemRRow1442 MemRCol1442 10000.000000
R11443 MemRRow1443 MemRCol1443 10000.000000
R11444 MemRRow1444 MemRCol1444 10000.000000
R11445 MemRRow1445 MemRCol1445 10000.000000
R11446 MemRRow1446 MemRCol1446 10000.000000
R11447 MemRRow1447 MemRCol1447 10000.000000
R11448 MemRRow1448 MemRCol1448 10000.000000
R11449 MemRRow1449 MemRCol1449 10000.000000
R11450 MemRRow1450 MemRCol1450 10000.000000
R1151 MemRRow151 MemRCol151 10000.000000
R1152 MemRRow152 MemRCol152 10000.000000
R1153 MemRRow153 MemRCol153 10000.000000
R1154 MemRRow154 MemRCol154 10000.000000
R1155 MemRRow155 MemRCol155 10000.000000
R1156 MemRRow156 MemRCol156 10000.000000
R1157 MemRRow157 MemRCol157 10000.000000
R1158 MemRRow158 MemRCol158 10000.000000
R1159 MemRRow159 MemRCol159 10000.000000
R11510 MemRRow1510 MemRCol1510 10000.000000
R11511 MemRRow1511 MemRCol1511 10000.000000
R11512 MemRRow1512 MemRCol1512 10000.000000
R11513 MemRRow1513 MemRCol1513 10000.000000
R11514 MemRRow1514 MemRCol1514 10000.000000
R11515 MemRRow1515 MemRCol1515 10000.000000
R11516 MemRRow1516 MemRCol1516 10000.000000
R11517 MemRRow1517 MemRCol1517 10000.000000
R11518 MemRRow1518 MemRCol1518 10000.000000
R11519 MemRRow1519 MemRCol1519 10000.000000
R11520 MemRRow1520 MemRCol1520 10000.000000
R11521 MemRRow1521 MemRCol1521 10000.000000
R11522 MemRRow1522 MemRCol1522 10000.000000
R11523 MemRRow1523 MemRCol1523 10000.000000
R11524 MemRRow1524 MemRCol1524 10000.000000
R11525 MemRRow1525 MemRCol1525 10000.000000
R11526 MemRRow1526 MemRCol1526 10000.000000
R11527 MemRRow1527 MemRCol1527 10000.000000
R11528 MemRRow1528 MemRCol1528 10000.000000
R11529 MemRRow1529 MemRCol1529 10000.000000
R11530 MemRRow1530 MemRCol1530 10000.000000
R11531 MemRRow1531 MemRCol1531 10000.000000
R11532 MemRRow1532 MemRCol1532 10000.000000
R11533 MemRRow1533 MemRCol1533 10000.000000
R11534 MemRRow1534 MemRCol1534 10000.000000
R11535 MemRRow1535 MemRCol1535 10000.000000
R11536 MemRRow1536 MemRCol1536 10000.000000
R11537 MemRRow1537 MemRCol1537 10000.000000
R11538 MemRRow1538 MemRCol1538 10000.000000
R11539 MemRRow1539 MemRCol1539 10000.000000
R11540 MemRRow1540 MemRCol1540 10000.000000
R11541 MemRRow1541 MemRCol1541 10000.000000
R11542 MemRRow1542 MemRCol1542 10000.000000
R11543 MemRRow1543 MemRCol1543 10000.000000
R11544 MemRRow1544 MemRCol1544 10000.000000
R11545 MemRRow1545 MemRCol1545 10000.000000
R11546 MemRRow1546 MemRCol1546 10000.000000
R11547 MemRRow1547 MemRCol1547 10000.000000
R11548 MemRRow1548 MemRCol1548 10000.000000
R11549 MemRRow1549 MemRCol1549 10000.000000
R11550 MemRRow1550 MemRCol1550 10000.000000
R1161 MemRRow161 MemRCol161 10000.000000
R1162 MemRRow162 MemRCol162 10000.000000
R1163 MemRRow163 MemRCol163 10000.000000
R1164 MemRRow164 MemRCol164 10000.000000
R1165 MemRRow165 MemRCol165 10000.000000
R1166 MemRRow166 MemRCol166 10000.000000
R1167 MemRRow167 MemRCol167 10000.000000
R1168 MemRRow168 MemRCol168 10000.000000
R1169 MemRRow169 MemRCol169 10000.000000
R11610 MemRRow1610 MemRCol1610 10000.000000
R11611 MemRRow1611 MemRCol1611 10000.000000
R11612 MemRRow1612 MemRCol1612 10000.000000
R11613 MemRRow1613 MemRCol1613 10000.000000
R11614 MemRRow1614 MemRCol1614 10000.000000
R11615 MemRRow1615 MemRCol1615 10000.000000
R11616 MemRRow1616 MemRCol1616 10000.000000
R11617 MemRRow1617 MemRCol1617 10000.000000
R11618 MemRRow1618 MemRCol1618 10000.000000
R11619 MemRRow1619 MemRCol1619 10000.000000
R11620 MemRRow1620 MemRCol1620 10000.000000
R11621 MemRRow1621 MemRCol1621 10000.000000
R11622 MemRRow1622 MemRCol1622 10000.000000
R11623 MemRRow1623 MemRCol1623 10000.000000
R11624 MemRRow1624 MemRCol1624 10000.000000
R11625 MemRRow1625 MemRCol1625 10000.000000
R11626 MemRRow1626 MemRCol1626 10000.000000
R11627 MemRRow1627 MemRCol1627 10000.000000
R11628 MemRRow1628 MemRCol1628 10000.000000
R11629 MemRRow1629 MemRCol1629 10000.000000
R11630 MemRRow1630 MemRCol1630 10000.000000
R11631 MemRRow1631 MemRCol1631 10000.000000
R11632 MemRRow1632 MemRCol1632 10000.000000
R11633 MemRRow1633 MemRCol1633 10000.000000
R11634 MemRRow1634 MemRCol1634 10000.000000
R11635 MemRRow1635 MemRCol1635 10000.000000
R11636 MemRRow1636 MemRCol1636 10000.000000
R11637 MemRRow1637 MemRCol1637 10000.000000
R11638 MemRRow1638 MemRCol1638 10000.000000
R11639 MemRRow1639 MemRCol1639 10000.000000
R11640 MemRRow1640 MemRCol1640 10000.000000
R11641 MemRRow1641 MemRCol1641 10000.000000
R11642 MemRRow1642 MemRCol1642 10000.000000
R11643 MemRRow1643 MemRCol1643 10000.000000
R11644 MemRRow1644 MemRCol1644 10000.000000
R11645 MemRRow1645 MemRCol1645 10000.000000
R11646 MemRRow1646 MemRCol1646 10000.000000
R11647 MemRRow1647 MemRCol1647 10000.000000
R11648 MemRRow1648 MemRCol1648 10000.000000
R11649 MemRRow1649 MemRCol1649 10000.000000
R11650 MemRRow1650 MemRCol1650 10000.000000
R1171 MemRRow171 MemRCol171 10000.000000
R1172 MemRRow172 MemRCol172 10000.000000
R1173 MemRRow173 MemRCol173 10000.000000
R1174 MemRRow174 MemRCol174 10000.000000
R1175 MemRRow175 MemRCol175 10000.000000
R1176 MemRRow176 MemRCol176 10000.000000
R1177 MemRRow177 MemRCol177 10000.000000
R1178 MemRRow178 MemRCol178 10000.000000
R1179 MemRRow179 MemRCol179 10000.000000
R11710 MemRRow1710 MemRCol1710 10000.000000
R11711 MemRRow1711 MemRCol1711 10000.000000
R11712 MemRRow1712 MemRCol1712 10000.000000
R11713 MemRRow1713 MemRCol1713 10000.000000
R11714 MemRRow1714 MemRCol1714 10000.000000
R11715 MemRRow1715 MemRCol1715 10000.000000
R11716 MemRRow1716 MemRCol1716 10000.000000
R11717 MemRRow1717 MemRCol1717 10000.000000
R11718 MemRRow1718 MemRCol1718 10000.000000
R11719 MemRRow1719 MemRCol1719 10000.000000
R11720 MemRRow1720 MemRCol1720 10000.000000
R11721 MemRRow1721 MemRCol1721 10000.000000
R11722 MemRRow1722 MemRCol1722 10000.000000
R11723 MemRRow1723 MemRCol1723 10000.000000
R11724 MemRRow1724 MemRCol1724 10000.000000
R11725 MemRRow1725 MemRCol1725 10000.000000
R11726 MemRRow1726 MemRCol1726 10000.000000
R11727 MemRRow1727 MemRCol1727 10000.000000
R11728 MemRRow1728 MemRCol1728 10000.000000
R11729 MemRRow1729 MemRCol1729 10000.000000
R11730 MemRRow1730 MemRCol1730 10000.000000
R11731 MemRRow1731 MemRCol1731 10000.000000
R11732 MemRRow1732 MemRCol1732 10000.000000
R11733 MemRRow1733 MemRCol1733 10000.000000
R11734 MemRRow1734 MemRCol1734 10000.000000
R11735 MemRRow1735 MemRCol1735 10000.000000
R11736 MemRRow1736 MemRCol1736 10000.000000
R11737 MemRRow1737 MemRCol1737 10000.000000
R11738 MemRRow1738 MemRCol1738 10000.000000
R11739 MemRRow1739 MemRCol1739 10000.000000
R11740 MemRRow1740 MemRCol1740 10000.000000
R11741 MemRRow1741 MemRCol1741 10000.000000
R11742 MemRRow1742 MemRCol1742 10000.000000
R11743 MemRRow1743 MemRCol1743 10000.000000
R11744 MemRRow1744 MemRCol1744 10000.000000
R11745 MemRRow1745 MemRCol1745 10000.000000
R11746 MemRRow1746 MemRCol1746 10000.000000
R11747 MemRRow1747 MemRCol1747 10000.000000
R11748 MemRRow1748 MemRCol1748 10000.000000
R11749 MemRRow1749 MemRCol1749 10000.000000
R11750 MemRRow1750 MemRCol1750 10000.000000
R1181 MemRRow181 MemRCol181 10000.000000
R1182 MemRRow182 MemRCol182 10000.000000
R1183 MemRRow183 MemRCol183 10000.000000
R1184 MemRRow184 MemRCol184 10000.000000
R1185 MemRRow185 MemRCol185 10000.000000
R1186 MemRRow186 MemRCol186 10000.000000
R1187 MemRRow187 MemRCol187 10000.000000
R1188 MemRRow188 MemRCol188 10000.000000
R1189 MemRRow189 MemRCol189 10000.000000
R11810 MemRRow1810 MemRCol1810 10000.000000
R11811 MemRRow1811 MemRCol1811 10000.000000
R11812 MemRRow1812 MemRCol1812 10000.000000
R11813 MemRRow1813 MemRCol1813 10000.000000
R11814 MemRRow1814 MemRCol1814 10000.000000
R11815 MemRRow1815 MemRCol1815 10000.000000
R11816 MemRRow1816 MemRCol1816 10000.000000
R11817 MemRRow1817 MemRCol1817 10000.000000
R11818 MemRRow1818 MemRCol1818 10000.000000
R11819 MemRRow1819 MemRCol1819 10000.000000
R11820 MemRRow1820 MemRCol1820 10000.000000
R11821 MemRRow1821 MemRCol1821 10000.000000
R11822 MemRRow1822 MemRCol1822 10000.000000
R11823 MemRRow1823 MemRCol1823 10000.000000
R11824 MemRRow1824 MemRCol1824 10000.000000
R11825 MemRRow1825 MemRCol1825 10000.000000
R11826 MemRRow1826 MemRCol1826 10000.000000
R11827 MemRRow1827 MemRCol1827 10000.000000
R11828 MemRRow1828 MemRCol1828 10000.000000
R11829 MemRRow1829 MemRCol1829 10000.000000
R11830 MemRRow1830 MemRCol1830 10000.000000
R11831 MemRRow1831 MemRCol1831 10000.000000
R11832 MemRRow1832 MemRCol1832 10000.000000
R11833 MemRRow1833 MemRCol1833 10000.000000
R11834 MemRRow1834 MemRCol1834 10000.000000
R11835 MemRRow1835 MemRCol1835 10000.000000
R11836 MemRRow1836 MemRCol1836 10000.000000
R11837 MemRRow1837 MemRCol1837 10000.000000
R11838 MemRRow1838 MemRCol1838 10000.000000
R11839 MemRRow1839 MemRCol1839 10000.000000
R11840 MemRRow1840 MemRCol1840 10000.000000
R11841 MemRRow1841 MemRCol1841 10000.000000
R11842 MemRRow1842 MemRCol1842 10000.000000
R11843 MemRRow1843 MemRCol1843 10000.000000
R11844 MemRRow1844 MemRCol1844 10000.000000
R11845 MemRRow1845 MemRCol1845 10000.000000
R11846 MemRRow1846 MemRCol1846 10000.000000
R11847 MemRRow1847 MemRCol1847 10000.000000
R11848 MemRRow1848 MemRCol1848 10000.000000
R11849 MemRRow1849 MemRCol1849 10000.000000
R11850 MemRRow1850 MemRCol1850 10000.000000
R1191 MemRRow191 MemRCol191 10000.000000
R1192 MemRRow192 MemRCol192 10000.000000
R1193 MemRRow193 MemRCol193 10000.000000
R1194 MemRRow194 MemRCol194 10000.000000
R1195 MemRRow195 MemRCol195 10000.000000
R1196 MemRRow196 MemRCol196 10000.000000
R1197 MemRRow197 MemRCol197 10000.000000
R1198 MemRRow198 MemRCol198 10000.000000
R1199 MemRRow199 MemRCol199 10000.000000
R11910 MemRRow1910 MemRCol1910 10000.000000
R11911 MemRRow1911 MemRCol1911 10000.000000
R11912 MemRRow1912 MemRCol1912 10000.000000
R11913 MemRRow1913 MemRCol1913 10000.000000
R11914 MemRRow1914 MemRCol1914 10000.000000
R11915 MemRRow1915 MemRCol1915 10000.000000
R11916 MemRRow1916 MemRCol1916 10000.000000
R11917 MemRRow1917 MemRCol1917 10000.000000
R11918 MemRRow1918 MemRCol1918 10000.000000
R11919 MemRRow1919 MemRCol1919 10000.000000
R11920 MemRRow1920 MemRCol1920 10000.000000
R11921 MemRRow1921 MemRCol1921 10000.000000
R11922 MemRRow1922 MemRCol1922 10000.000000
R11923 MemRRow1923 MemRCol1923 10000.000000
R11924 MemRRow1924 MemRCol1924 10000.000000
R11925 MemRRow1925 MemRCol1925 10000.000000
R11926 MemRRow1926 MemRCol1926 10000.000000
R11927 MemRRow1927 MemRCol1927 10000.000000
R11928 MemRRow1928 MemRCol1928 10000.000000
R11929 MemRRow1929 MemRCol1929 10000.000000
R11930 MemRRow1930 MemRCol1930 10000.000000
R11931 MemRRow1931 MemRCol1931 10000.000000
R11932 MemRRow1932 MemRCol1932 10000.000000
R11933 MemRRow1933 MemRCol1933 10000.000000
R11934 MemRRow1934 MemRCol1934 10000.000000
R11935 MemRRow1935 MemRCol1935 10000.000000
R11936 MemRRow1936 MemRCol1936 10000.000000
R11937 MemRRow1937 MemRCol1937 10000.000000
R11938 MemRRow1938 MemRCol1938 10000.000000
R11939 MemRRow1939 MemRCol1939 10000.000000
R11940 MemRRow1940 MemRCol1940 10000.000000
R11941 MemRRow1941 MemRCol1941 10000.000000
R11942 MemRRow1942 MemRCol1942 10000.000000
R11943 MemRRow1943 MemRCol1943 10000.000000
R11944 MemRRow1944 MemRCol1944 10000.000000
R11945 MemRRow1945 MemRCol1945 10000.000000
R11946 MemRRow1946 MemRCol1946 10000.000000
R11947 MemRRow1947 MemRCol1947 10000.000000
R11948 MemRRow1948 MemRCol1948 10000.000000
R11949 MemRRow1949 MemRCol1949 10000.000000
R11950 MemRRow1950 MemRCol1950 10000.000000
R1201 MemRRow201 MemRCol201 10000.000000
R1202 MemRRow202 MemRCol202 10000.000000
R1203 MemRRow203 MemRCol203 10000.000000
R1204 MemRRow204 MemRCol204 10000.000000
R1205 MemRRow205 MemRCol205 10000.000000
R1206 MemRRow206 MemRCol206 10000.000000
R1207 MemRRow207 MemRCol207 10000.000000
R1208 MemRRow208 MemRCol208 10000.000000
R1209 MemRRow209 MemRCol209 10000.000000
R12010 MemRRow2010 MemRCol2010 10000.000000
R12011 MemRRow2011 MemRCol2011 10000.000000
R12012 MemRRow2012 MemRCol2012 10000.000000
R12013 MemRRow2013 MemRCol2013 10000.000000
R12014 MemRRow2014 MemRCol2014 10000.000000
R12015 MemRRow2015 MemRCol2015 10000.000000
R12016 MemRRow2016 MemRCol2016 10000.000000
R12017 MemRRow2017 MemRCol2017 10000.000000
R12018 MemRRow2018 MemRCol2018 10000.000000
R12019 MemRRow2019 MemRCol2019 10000.000000
R12020 MemRRow2020 MemRCol2020 10000.000000
R12021 MemRRow2021 MemRCol2021 10000.000000
R12022 MemRRow2022 MemRCol2022 10000.000000
R12023 MemRRow2023 MemRCol2023 10000.000000
R12024 MemRRow2024 MemRCol2024 10000.000000
R12025 MemRRow2025 MemRCol2025 10000.000000
R12026 MemRRow2026 MemRCol2026 10000.000000
R12027 MemRRow2027 MemRCol2027 10000.000000
R12028 MemRRow2028 MemRCol2028 10000.000000
R12029 MemRRow2029 MemRCol2029 10000.000000
R12030 MemRRow2030 MemRCol2030 10000.000000
R12031 MemRRow2031 MemRCol2031 10000.000000
R12032 MemRRow2032 MemRCol2032 10000.000000
R12033 MemRRow2033 MemRCol2033 10000.000000
R12034 MemRRow2034 MemRCol2034 10000.000000
R12035 MemRRow2035 MemRCol2035 10000.000000
R12036 MemRRow2036 MemRCol2036 10000.000000
R12037 MemRRow2037 MemRCol2037 10000.000000
R12038 MemRRow2038 MemRCol2038 10000.000000
R12039 MemRRow2039 MemRCol2039 10000.000000
R12040 MemRRow2040 MemRCol2040 10000.000000
R12041 MemRRow2041 MemRCol2041 10000.000000
R12042 MemRRow2042 MemRCol2042 10000.000000
R12043 MemRRow2043 MemRCol2043 10000.000000
R12044 MemRRow2044 MemRCol2044 10000.000000
R12045 MemRRow2045 MemRCol2045 10000.000000
R12046 MemRRow2046 MemRCol2046 10000.000000
R12047 MemRRow2047 MemRCol2047 10000.000000
R12048 MemRRow2048 MemRCol2048 10000.000000
R12049 MemRRow2049 MemRCol2049 10000.000000
R12050 MemRRow2050 MemRCol2050 10000.000000
R1211 MemRRow211 MemRCol211 10000.000000
R1212 MemRRow212 MemRCol212 10000.000000
R1213 MemRRow213 MemRCol213 10000.000000
R1214 MemRRow214 MemRCol214 10000.000000
R1215 MemRRow215 MemRCol215 10000.000000
R1216 MemRRow216 MemRCol216 10000.000000
R1217 MemRRow217 MemRCol217 10000.000000
R1218 MemRRow218 MemRCol218 10000.000000
R1219 MemRRow219 MemRCol219 10000.000000
R12110 MemRRow2110 MemRCol2110 10000.000000
R12111 MemRRow2111 MemRCol2111 10000.000000
R12112 MemRRow2112 MemRCol2112 10000.000000
R12113 MemRRow2113 MemRCol2113 10000.000000
R12114 MemRRow2114 MemRCol2114 10000.000000
R12115 MemRRow2115 MemRCol2115 10000.000000
R12116 MemRRow2116 MemRCol2116 10000.000000
R12117 MemRRow2117 MemRCol2117 10000.000000
R12118 MemRRow2118 MemRCol2118 10000.000000
R12119 MemRRow2119 MemRCol2119 10000.000000
R12120 MemRRow2120 MemRCol2120 10000.000000
R12121 MemRRow2121 MemRCol2121 10000.000000
R12122 MemRRow2122 MemRCol2122 10000.000000
R12123 MemRRow2123 MemRCol2123 10000.000000
R12124 MemRRow2124 MemRCol2124 10000.000000
R12125 MemRRow2125 MemRCol2125 10000.000000
R12126 MemRRow2126 MemRCol2126 10000.000000
R12127 MemRRow2127 MemRCol2127 10000.000000
R12128 MemRRow2128 MemRCol2128 10000.000000
R12129 MemRRow2129 MemRCol2129 10000.000000
R12130 MemRRow2130 MemRCol2130 10000.000000
R12131 MemRRow2131 MemRCol2131 10000.000000
R12132 MemRRow2132 MemRCol2132 10000.000000
R12133 MemRRow2133 MemRCol2133 10000.000000
R12134 MemRRow2134 MemRCol2134 10000.000000
R12135 MemRRow2135 MemRCol2135 10000.000000
R12136 MemRRow2136 MemRCol2136 10000.000000
R12137 MemRRow2137 MemRCol2137 10000.000000
R12138 MemRRow2138 MemRCol2138 10000.000000
R12139 MemRRow2139 MemRCol2139 10000.000000
R12140 MemRRow2140 MemRCol2140 10000.000000
R12141 MemRRow2141 MemRCol2141 10000.000000
R12142 MemRRow2142 MemRCol2142 10000.000000
R12143 MemRRow2143 MemRCol2143 10000.000000
R12144 MemRRow2144 MemRCol2144 10000.000000
R12145 MemRRow2145 MemRCol2145 10000.000000
R12146 MemRRow2146 MemRCol2146 10000.000000
R12147 MemRRow2147 MemRCol2147 10000.000000
R12148 MemRRow2148 MemRCol2148 10000.000000
R12149 MemRRow2149 MemRCol2149 10000.000000
R12150 MemRRow2150 MemRCol2150 10000.000000
R1221 MemRRow221 MemRCol221 10000.000000
R1222 MemRRow222 MemRCol222 10000.000000
R1223 MemRRow223 MemRCol223 10000.000000
R1224 MemRRow224 MemRCol224 10000.000000
R1225 MemRRow225 MemRCol225 10000.000000
R1226 MemRRow226 MemRCol226 10000.000000
R1227 MemRRow227 MemRCol227 10000.000000
R1228 MemRRow228 MemRCol228 10000.000000
R1229 MemRRow229 MemRCol229 10000.000000
R12210 MemRRow2210 MemRCol2210 10000.000000
R12211 MemRRow2211 MemRCol2211 10000.000000
R12212 MemRRow2212 MemRCol2212 10000.000000
R12213 MemRRow2213 MemRCol2213 10000.000000
R12214 MemRRow2214 MemRCol2214 10000.000000
R12215 MemRRow2215 MemRCol2215 10000.000000
R12216 MemRRow2216 MemRCol2216 10000.000000
R12217 MemRRow2217 MemRCol2217 10000.000000
R12218 MemRRow2218 MemRCol2218 10000.000000
R12219 MemRRow2219 MemRCol2219 10000.000000
R12220 MemRRow2220 MemRCol2220 10000.000000
R12221 MemRRow2221 MemRCol2221 10000.000000
R12222 MemRRow2222 MemRCol2222 10000.000000
R12223 MemRRow2223 MemRCol2223 10000.000000
R12224 MemRRow2224 MemRCol2224 10000.000000
R12225 MemRRow2225 MemRCol2225 10000.000000
R12226 MemRRow2226 MemRCol2226 10000.000000
R12227 MemRRow2227 MemRCol2227 10000.000000
R12228 MemRRow2228 MemRCol2228 10000.000000
R12229 MemRRow2229 MemRCol2229 10000.000000
R12230 MemRRow2230 MemRCol2230 10000.000000
R12231 MemRRow2231 MemRCol2231 10000.000000
R12232 MemRRow2232 MemRCol2232 10000.000000
R12233 MemRRow2233 MemRCol2233 10000.000000
R12234 MemRRow2234 MemRCol2234 10000.000000
R12235 MemRRow2235 MemRCol2235 10000.000000
R12236 MemRRow2236 MemRCol2236 10000.000000
R12237 MemRRow2237 MemRCol2237 10000.000000
R12238 MemRRow2238 MemRCol2238 10000.000000
R12239 MemRRow2239 MemRCol2239 10000.000000
R12240 MemRRow2240 MemRCol2240 10000.000000
R12241 MemRRow2241 MemRCol2241 10000.000000
R12242 MemRRow2242 MemRCol2242 10000.000000
R12243 MemRRow2243 MemRCol2243 10000.000000
R12244 MemRRow2244 MemRCol2244 10000.000000
R12245 MemRRow2245 MemRCol2245 10000.000000
R12246 MemRRow2246 MemRCol2246 10000.000000
R12247 MemRRow2247 MemRCol2247 10000.000000
R12248 MemRRow2248 MemRCol2248 10000.000000
R12249 MemRRow2249 MemRCol2249 10000.000000
R12250 MemRRow2250 MemRCol2250 10000.000000
R1231 MemRRow231 MemRCol231 10000.000000
R1232 MemRRow232 MemRCol232 10000.000000
R1233 MemRRow233 MemRCol233 10000.000000
R1234 MemRRow234 MemRCol234 10000.000000
R1235 MemRRow235 MemRCol235 10000.000000
R1236 MemRRow236 MemRCol236 10000.000000
R1237 MemRRow237 MemRCol237 10000.000000
R1238 MemRRow238 MemRCol238 10000.000000
R1239 MemRRow239 MemRCol239 10000.000000
R12310 MemRRow2310 MemRCol2310 10000.000000
R12311 MemRRow2311 MemRCol2311 10000.000000
R12312 MemRRow2312 MemRCol2312 10000.000000
R12313 MemRRow2313 MemRCol2313 10000.000000
R12314 MemRRow2314 MemRCol2314 10000.000000
R12315 MemRRow2315 MemRCol2315 10000.000000
R12316 MemRRow2316 MemRCol2316 10000.000000
R12317 MemRRow2317 MemRCol2317 10000.000000
R12318 MemRRow2318 MemRCol2318 10000.000000
R12319 MemRRow2319 MemRCol2319 10000.000000
R12320 MemRRow2320 MemRCol2320 10000.000000
R12321 MemRRow2321 MemRCol2321 10000.000000
R12322 MemRRow2322 MemRCol2322 10000.000000
R12323 MemRRow2323 MemRCol2323 10000.000000
R12324 MemRRow2324 MemRCol2324 10000.000000
R12325 MemRRow2325 MemRCol2325 10000.000000
R12326 MemRRow2326 MemRCol2326 10000.000000
R12327 MemRRow2327 MemRCol2327 10000.000000
R12328 MemRRow2328 MemRCol2328 10000.000000
R12329 MemRRow2329 MemRCol2329 10000.000000
R12330 MemRRow2330 MemRCol2330 10000.000000
R12331 MemRRow2331 MemRCol2331 10000.000000
R12332 MemRRow2332 MemRCol2332 10000.000000
R12333 MemRRow2333 MemRCol2333 10000.000000
R12334 MemRRow2334 MemRCol2334 10000.000000
R12335 MemRRow2335 MemRCol2335 10000.000000
R12336 MemRRow2336 MemRCol2336 10000.000000
R12337 MemRRow2337 MemRCol2337 10000.000000
R12338 MemRRow2338 MemRCol2338 10000.000000
R12339 MemRRow2339 MemRCol2339 10000.000000
R12340 MemRRow2340 MemRCol2340 10000.000000
R12341 MemRRow2341 MemRCol2341 10000.000000
R12342 MemRRow2342 MemRCol2342 10000.000000
R12343 MemRRow2343 MemRCol2343 10000.000000
R12344 MemRRow2344 MemRCol2344 10000.000000
R12345 MemRRow2345 MemRCol2345 10000.000000
R12346 MemRRow2346 MemRCol2346 10000.000000
R12347 MemRRow2347 MemRCol2347 10000.000000
R12348 MemRRow2348 MemRCol2348 10000.000000
R12349 MemRRow2349 MemRCol2349 10000.000000
R12350 MemRRow2350 MemRCol2350 10000.000000
R1241 MemRRow241 MemRCol241 10000.000000
R1242 MemRRow242 MemRCol242 10000.000000
R1243 MemRRow243 MemRCol243 10000.000000
R1244 MemRRow244 MemRCol244 10000.000000
R1245 MemRRow245 MemRCol245 10000.000000
R1246 MemRRow246 MemRCol246 10000.000000
R1247 MemRRow247 MemRCol247 10000.000000
R1248 MemRRow248 MemRCol248 10000.000000
R1249 MemRRow249 MemRCol249 10000.000000
R12410 MemRRow2410 MemRCol2410 10000.000000
R12411 MemRRow2411 MemRCol2411 10000.000000
R12412 MemRRow2412 MemRCol2412 10000.000000
R12413 MemRRow2413 MemRCol2413 10000.000000
R12414 MemRRow2414 MemRCol2414 10000.000000
R12415 MemRRow2415 MemRCol2415 10000.000000
R12416 MemRRow2416 MemRCol2416 10000.000000
R12417 MemRRow2417 MemRCol2417 10000.000000
R12418 MemRRow2418 MemRCol2418 10000.000000
R12419 MemRRow2419 MemRCol2419 10000.000000
R12420 MemRRow2420 MemRCol2420 10000.000000
R12421 MemRRow2421 MemRCol2421 10000.000000
R12422 MemRRow2422 MemRCol2422 10000.000000
R12423 MemRRow2423 MemRCol2423 10000.000000
R12424 MemRRow2424 MemRCol2424 10000.000000
R12425 MemRRow2425 MemRCol2425 10000.000000
R12426 MemRRow2426 MemRCol2426 10000.000000
R12427 MemRRow2427 MemRCol2427 10000.000000
R12428 MemRRow2428 MemRCol2428 10000.000000
R12429 MemRRow2429 MemRCol2429 10000.000000
R12430 MemRRow2430 MemRCol2430 10000.000000
R12431 MemRRow2431 MemRCol2431 10000.000000
R12432 MemRRow2432 MemRCol2432 10000.000000
R12433 MemRRow2433 MemRCol2433 10000.000000
R12434 MemRRow2434 MemRCol2434 10000.000000
R12435 MemRRow2435 MemRCol2435 10000.000000
R12436 MemRRow2436 MemRCol2436 10000.000000
R12437 MemRRow2437 MemRCol2437 10000.000000
R12438 MemRRow2438 MemRCol2438 10000.000000
R12439 MemRRow2439 MemRCol2439 10000.000000
R12440 MemRRow2440 MemRCol2440 10000.000000
R12441 MemRRow2441 MemRCol2441 10000.000000
R12442 MemRRow2442 MemRCol2442 10000.000000
R12443 MemRRow2443 MemRCol2443 10000.000000
R12444 MemRRow2444 MemRCol2444 10000.000000
R12445 MemRRow2445 MemRCol2445 10000.000000
R12446 MemRRow2446 MemRCol2446 10000.000000
R12447 MemRRow2447 MemRCol2447 10000.000000
R12448 MemRRow2448 MemRCol2448 10000.000000
R12449 MemRRow2449 MemRCol2449 10000.000000
R12450 MemRRow2450 MemRCol2450 10000.000000
R1251 MemRRow251 MemRCol251 10000.000000
R1252 MemRRow252 MemRCol252 10000.000000
R1253 MemRRow253 MemRCol253 10000.000000
R1254 MemRRow254 MemRCol254 10000.000000
R1255 MemRRow255 MemRCol255 10000.000000
R1256 MemRRow256 MemRCol256 10000.000000
R1257 MemRRow257 MemRCol257 10000.000000
R1258 MemRRow258 MemRCol258 10000.000000
R1259 MemRRow259 MemRCol259 10000.000000
R12510 MemRRow2510 MemRCol2510 10000.000000
R12511 MemRRow2511 MemRCol2511 10000.000000
R12512 MemRRow2512 MemRCol2512 10000.000000
R12513 MemRRow2513 MemRCol2513 10000.000000
R12514 MemRRow2514 MemRCol2514 10000.000000
R12515 MemRRow2515 MemRCol2515 10000.000000
R12516 MemRRow2516 MemRCol2516 10000.000000
R12517 MemRRow2517 MemRCol2517 10000.000000
R12518 MemRRow2518 MemRCol2518 10000.000000
R12519 MemRRow2519 MemRCol2519 10000.000000
R12520 MemRRow2520 MemRCol2520 10000.000000
R12521 MemRRow2521 MemRCol2521 10000.000000
R12522 MemRRow2522 MemRCol2522 10000.000000
R12523 MemRRow2523 MemRCol2523 10000.000000
R12524 MemRRow2524 MemRCol2524 10000.000000
R12525 MemRRow2525 MemRCol2525 10000.000000
R12526 MemRRow2526 MemRCol2526 10000.000000
R12527 MemRRow2527 MemRCol2527 10000.000000
R12528 MemRRow2528 MemRCol2528 10000.000000
R12529 MemRRow2529 MemRCol2529 10000.000000
R12530 MemRRow2530 MemRCol2530 10000.000000
R12531 MemRRow2531 MemRCol2531 10000.000000
R12532 MemRRow2532 MemRCol2532 10000.000000
R12533 MemRRow2533 MemRCol2533 10000.000000
R12534 MemRRow2534 MemRCol2534 10000.000000
R12535 MemRRow2535 MemRCol2535 10000.000000
R12536 MemRRow2536 MemRCol2536 10000.000000
R12537 MemRRow2537 MemRCol2537 10000.000000
R12538 MemRRow2538 MemRCol2538 10000.000000
R12539 MemRRow2539 MemRCol2539 10000.000000
R12540 MemRRow2540 MemRCol2540 10000.000000
R12541 MemRRow2541 MemRCol2541 10000.000000
R12542 MemRRow2542 MemRCol2542 10000.000000
R12543 MemRRow2543 MemRCol2543 10000.000000
R12544 MemRRow2544 MemRCol2544 10000.000000
R12545 MemRRow2545 MemRCol2545 10000.000000
R12546 MemRRow2546 MemRCol2546 10000.000000
R12547 MemRRow2547 MemRCol2547 10000.000000
R12548 MemRRow2548 MemRCol2548 10000.000000
R12549 MemRRow2549 MemRCol2549 10000.000000
R12550 MemRRow2550 MemRCol2550 10000.000000
R1261 MemRRow261 MemRCol261 10000.000000
R1262 MemRRow262 MemRCol262 10000.000000
R1263 MemRRow263 MemRCol263 10000.000000
R1264 MemRRow264 MemRCol264 10000.000000
R1265 MemRRow265 MemRCol265 10000.000000
R1266 MemRRow266 MemRCol266 10000.000000
R1267 MemRRow267 MemRCol267 10000.000000
R1268 MemRRow268 MemRCol268 10000.000000
R1269 MemRRow269 MemRCol269 10000.000000
R12610 MemRRow2610 MemRCol2610 10000.000000
R12611 MemRRow2611 MemRCol2611 10000.000000
R12612 MemRRow2612 MemRCol2612 10000.000000
R12613 MemRRow2613 MemRCol2613 10000.000000
R12614 MemRRow2614 MemRCol2614 10000.000000
R12615 MemRRow2615 MemRCol2615 10000.000000
R12616 MemRRow2616 MemRCol2616 10000.000000
R12617 MemRRow2617 MemRCol2617 10000.000000
R12618 MemRRow2618 MemRCol2618 10000.000000
R12619 MemRRow2619 MemRCol2619 10000.000000
R12620 MemRRow2620 MemRCol2620 10000.000000
R12621 MemRRow2621 MemRCol2621 10000.000000
R12622 MemRRow2622 MemRCol2622 10000.000000
R12623 MemRRow2623 MemRCol2623 10000.000000
R12624 MemRRow2624 MemRCol2624 10000.000000
R12625 MemRRow2625 MemRCol2625 10000.000000
R12626 MemRRow2626 MemRCol2626 10000.000000
R12627 MemRRow2627 MemRCol2627 10000.000000
R12628 MemRRow2628 MemRCol2628 10000.000000
R12629 MemRRow2629 MemRCol2629 10000.000000
R12630 MemRRow2630 MemRCol2630 10000.000000
R12631 MemRRow2631 MemRCol2631 10000.000000
R12632 MemRRow2632 MemRCol2632 10000.000000
R12633 MemRRow2633 MemRCol2633 10000.000000
R12634 MemRRow2634 MemRCol2634 10000.000000
R12635 MemRRow2635 MemRCol2635 10000.000000
R12636 MemRRow2636 MemRCol2636 10000.000000
R12637 MemRRow2637 MemRCol2637 10000.000000
R12638 MemRRow2638 MemRCol2638 10000.000000
R12639 MemRRow2639 MemRCol2639 10000.000000
R12640 MemRRow2640 MemRCol2640 10000.000000
R12641 MemRRow2641 MemRCol2641 10000.000000
R12642 MemRRow2642 MemRCol2642 10000.000000
R12643 MemRRow2643 MemRCol2643 10000.000000
R12644 MemRRow2644 MemRCol2644 10000.000000
R12645 MemRRow2645 MemRCol2645 10000.000000
R12646 MemRRow2646 MemRCol2646 10000.000000
R12647 MemRRow2647 MemRCol2647 10000.000000
R12648 MemRRow2648 MemRCol2648 10000.000000
R12649 MemRRow2649 MemRCol2649 10000.000000
R12650 MemRRow2650 MemRCol2650 10000.000000
R1271 MemRRow271 MemRCol271 10000.000000
R1272 MemRRow272 MemRCol272 10000.000000
R1273 MemRRow273 MemRCol273 10000.000000
R1274 MemRRow274 MemRCol274 10000.000000
R1275 MemRRow275 MemRCol275 10000.000000
R1276 MemRRow276 MemRCol276 10000.000000
R1277 MemRRow277 MemRCol277 10000.000000
R1278 MemRRow278 MemRCol278 10000.000000
R1279 MemRRow279 MemRCol279 10000.000000
R12710 MemRRow2710 MemRCol2710 10000.000000
R12711 MemRRow2711 MemRCol2711 10000.000000
R12712 MemRRow2712 MemRCol2712 10000.000000
R12713 MemRRow2713 MemRCol2713 10000.000000
R12714 MemRRow2714 MemRCol2714 10000.000000
R12715 MemRRow2715 MemRCol2715 10000.000000
R12716 MemRRow2716 MemRCol2716 10000.000000
R12717 MemRRow2717 MemRCol2717 10000.000000
R12718 MemRRow2718 MemRCol2718 10000.000000
R12719 MemRRow2719 MemRCol2719 10000.000000
R12720 MemRRow2720 MemRCol2720 10000.000000
R12721 MemRRow2721 MemRCol2721 10000.000000
R12722 MemRRow2722 MemRCol2722 10000.000000
R12723 MemRRow2723 MemRCol2723 10000.000000
R12724 MemRRow2724 MemRCol2724 10000.000000
R12725 MemRRow2725 MemRCol2725 10000.000000
R12726 MemRRow2726 MemRCol2726 10000.000000
R12727 MemRRow2727 MemRCol2727 10000.000000
R12728 MemRRow2728 MemRCol2728 10000.000000
R12729 MemRRow2729 MemRCol2729 10000.000000
R12730 MemRRow2730 MemRCol2730 10000.000000
R12731 MemRRow2731 MemRCol2731 10000.000000
R12732 MemRRow2732 MemRCol2732 10000.000000
R12733 MemRRow2733 MemRCol2733 10000.000000
R12734 MemRRow2734 MemRCol2734 10000.000000
R12735 MemRRow2735 MemRCol2735 10000.000000
R12736 MemRRow2736 MemRCol2736 10000.000000
R12737 MemRRow2737 MemRCol2737 10000.000000
R12738 MemRRow2738 MemRCol2738 10000.000000
R12739 MemRRow2739 MemRCol2739 10000.000000
R12740 MemRRow2740 MemRCol2740 10000.000000
R12741 MemRRow2741 MemRCol2741 10000.000000
R12742 MemRRow2742 MemRCol2742 10000.000000
R12743 MemRRow2743 MemRCol2743 10000.000000
R12744 MemRRow2744 MemRCol2744 10000.000000
R12745 MemRRow2745 MemRCol2745 10000.000000
R12746 MemRRow2746 MemRCol2746 10000.000000
R12747 MemRRow2747 MemRCol2747 10000.000000
R12748 MemRRow2748 MemRCol2748 10000.000000
R12749 MemRRow2749 MemRCol2749 10000.000000
R12750 MemRRow2750 MemRCol2750 10000.000000
R1281 MemRRow281 MemRCol281 10000.000000
R1282 MemRRow282 MemRCol282 10000.000000
R1283 MemRRow283 MemRCol283 10000.000000
R1284 MemRRow284 MemRCol284 10000.000000
R1285 MemRRow285 MemRCol285 10000.000000
R1286 MemRRow286 MemRCol286 10000.000000
R1287 MemRRow287 MemRCol287 10000.000000
R1288 MemRRow288 MemRCol288 10000.000000
R1289 MemRRow289 MemRCol289 10000.000000
R12810 MemRRow2810 MemRCol2810 10000.000000
R12811 MemRRow2811 MemRCol2811 10000.000000
R12812 MemRRow2812 MemRCol2812 10000.000000
R12813 MemRRow2813 MemRCol2813 10000.000000
R12814 MemRRow2814 MemRCol2814 10000.000000
R12815 MemRRow2815 MemRCol2815 10000.000000
R12816 MemRRow2816 MemRCol2816 10000.000000
R12817 MemRRow2817 MemRCol2817 10000.000000
R12818 MemRRow2818 MemRCol2818 10000.000000
R12819 MemRRow2819 MemRCol2819 10000.000000
R12820 MemRRow2820 MemRCol2820 10000.000000
R12821 MemRRow2821 MemRCol2821 10000.000000
R12822 MemRRow2822 MemRCol2822 10000.000000
R12823 MemRRow2823 MemRCol2823 10000.000000
R12824 MemRRow2824 MemRCol2824 10000.000000
R12825 MemRRow2825 MemRCol2825 10000.000000
R12826 MemRRow2826 MemRCol2826 10000.000000
R12827 MemRRow2827 MemRCol2827 10000.000000
R12828 MemRRow2828 MemRCol2828 10000.000000
R12829 MemRRow2829 MemRCol2829 10000.000000
R12830 MemRRow2830 MemRCol2830 10000.000000
R12831 MemRRow2831 MemRCol2831 10000.000000
R12832 MemRRow2832 MemRCol2832 10000.000000
R12833 MemRRow2833 MemRCol2833 10000.000000
R12834 MemRRow2834 MemRCol2834 10000.000000
R12835 MemRRow2835 MemRCol2835 10000.000000
R12836 MemRRow2836 MemRCol2836 10000.000000
R12837 MemRRow2837 MemRCol2837 10000.000000
R12838 MemRRow2838 MemRCol2838 10000.000000
R12839 MemRRow2839 MemRCol2839 10000.000000
R12840 MemRRow2840 MemRCol2840 10000.000000
R12841 MemRRow2841 MemRCol2841 10000.000000
R12842 MemRRow2842 MemRCol2842 10000.000000
R12843 MemRRow2843 MemRCol2843 10000.000000
R12844 MemRRow2844 MemRCol2844 10000.000000
R12845 MemRRow2845 MemRCol2845 10000.000000
R12846 MemRRow2846 MemRCol2846 10000.000000
R12847 MemRRow2847 MemRCol2847 10000.000000
R12848 MemRRow2848 MemRCol2848 10000.000000
R12849 MemRRow2849 MemRCol2849 10000.000000
R12850 MemRRow2850 MemRCol2850 10000.000000
R1291 MemRRow291 MemRCol291 10000.000000
R1292 MemRRow292 MemRCol292 10000.000000
R1293 MemRRow293 MemRCol293 10000.000000
R1294 MemRRow294 MemRCol294 10000.000000
R1295 MemRRow295 MemRCol295 10000.000000
R1296 MemRRow296 MemRCol296 10000.000000
R1297 MemRRow297 MemRCol297 10000.000000
R1298 MemRRow298 MemRCol298 10000.000000
R1299 MemRRow299 MemRCol299 10000.000000
R12910 MemRRow2910 MemRCol2910 10000.000000
R12911 MemRRow2911 MemRCol2911 10000.000000
R12912 MemRRow2912 MemRCol2912 10000.000000
R12913 MemRRow2913 MemRCol2913 10000.000000
R12914 MemRRow2914 MemRCol2914 10000.000000
R12915 MemRRow2915 MemRCol2915 10000.000000
R12916 MemRRow2916 MemRCol2916 10000.000000
R12917 MemRRow2917 MemRCol2917 10000.000000
R12918 MemRRow2918 MemRCol2918 10000.000000
R12919 MemRRow2919 MemRCol2919 10000.000000
R12920 MemRRow2920 MemRCol2920 10000.000000
R12921 MemRRow2921 MemRCol2921 10000.000000
R12922 MemRRow2922 MemRCol2922 10000.000000
R12923 MemRRow2923 MemRCol2923 10000.000000
R12924 MemRRow2924 MemRCol2924 10000.000000
R12925 MemRRow2925 MemRCol2925 10000.000000
R12926 MemRRow2926 MemRCol2926 10000.000000
R12927 MemRRow2927 MemRCol2927 10000.000000
R12928 MemRRow2928 MemRCol2928 10000.000000
R12929 MemRRow2929 MemRCol2929 10000.000000
R12930 MemRRow2930 MemRCol2930 10000.000000
R12931 MemRRow2931 MemRCol2931 10000.000000
R12932 MemRRow2932 MemRCol2932 10000.000000
R12933 MemRRow2933 MemRCol2933 10000.000000
R12934 MemRRow2934 MemRCol2934 10000.000000
R12935 MemRRow2935 MemRCol2935 10000.000000
R12936 MemRRow2936 MemRCol2936 10000.000000
R12937 MemRRow2937 MemRCol2937 10000.000000
R12938 MemRRow2938 MemRCol2938 10000.000000
R12939 MemRRow2939 MemRCol2939 10000.000000
R12940 MemRRow2940 MemRCol2940 10000.000000
R12941 MemRRow2941 MemRCol2941 10000.000000
R12942 MemRRow2942 MemRCol2942 10000.000000
R12943 MemRRow2943 MemRCol2943 10000.000000
R12944 MemRRow2944 MemRCol2944 10000.000000
R12945 MemRRow2945 MemRCol2945 10000.000000
R12946 MemRRow2946 MemRCol2946 10000.000000
R12947 MemRRow2947 MemRCol2947 10000.000000
R12948 MemRRow2948 MemRCol2948 10000.000000
R12949 MemRRow2949 MemRCol2949 10000.000000
R12950 MemRRow2950 MemRCol2950 10000.000000
R1301 MemRRow301 MemRCol301 10000.000000
R1302 MemRRow302 MemRCol302 10000.000000
R1303 MemRRow303 MemRCol303 10000.000000
R1304 MemRRow304 MemRCol304 10000.000000
R1305 MemRRow305 MemRCol305 10000.000000
R1306 MemRRow306 MemRCol306 10000.000000
R1307 MemRRow307 MemRCol307 10000.000000
R1308 MemRRow308 MemRCol308 10000.000000
R1309 MemRRow309 MemRCol309 10000.000000
R13010 MemRRow3010 MemRCol3010 10000.000000
R13011 MemRRow3011 MemRCol3011 10000.000000
R13012 MemRRow3012 MemRCol3012 10000.000000
R13013 MemRRow3013 MemRCol3013 10000.000000
R13014 MemRRow3014 MemRCol3014 10000.000000
R13015 MemRRow3015 MemRCol3015 10000.000000
R13016 MemRRow3016 MemRCol3016 10000.000000
R13017 MemRRow3017 MemRCol3017 10000.000000
R13018 MemRRow3018 MemRCol3018 10000.000000
R13019 MemRRow3019 MemRCol3019 10000.000000
R13020 MemRRow3020 MemRCol3020 10000.000000
R13021 MemRRow3021 MemRCol3021 10000.000000
R13022 MemRRow3022 MemRCol3022 10000.000000
R13023 MemRRow3023 MemRCol3023 10000.000000
R13024 MemRRow3024 MemRCol3024 10000.000000
R13025 MemRRow3025 MemRCol3025 10000.000000
R13026 MemRRow3026 MemRCol3026 10000.000000
R13027 MemRRow3027 MemRCol3027 10000.000000
R13028 MemRRow3028 MemRCol3028 10000.000000
R13029 MemRRow3029 MemRCol3029 10000.000000
R13030 MemRRow3030 MemRCol3030 10000.000000
R13031 MemRRow3031 MemRCol3031 10000.000000
R13032 MemRRow3032 MemRCol3032 10000.000000
R13033 MemRRow3033 MemRCol3033 10000.000000
R13034 MemRRow3034 MemRCol3034 10000.000000
R13035 MemRRow3035 MemRCol3035 10000.000000
R13036 MemRRow3036 MemRCol3036 10000.000000
R13037 MemRRow3037 MemRCol3037 10000.000000
R13038 MemRRow3038 MemRCol3038 10000.000000
R13039 MemRRow3039 MemRCol3039 10000.000000
R13040 MemRRow3040 MemRCol3040 10000.000000
R13041 MemRRow3041 MemRCol3041 10000.000000
R13042 MemRRow3042 MemRCol3042 10000.000000
R13043 MemRRow3043 MemRCol3043 10000.000000
R13044 MemRRow3044 MemRCol3044 10000.000000
R13045 MemRRow3045 MemRCol3045 10000.000000
R13046 MemRRow3046 MemRCol3046 10000.000000
R13047 MemRRow3047 MemRCol3047 10000.000000
R13048 MemRRow3048 MemRCol3048 10000.000000
R13049 MemRRow3049 MemRCol3049 10000.000000
R13050 MemRRow3050 MemRCol3050 10000.000000
R1311 MemRRow311 MemRCol311 10000.000000
R1312 MemRRow312 MemRCol312 10000.000000
R1313 MemRRow313 MemRCol313 10000.000000
R1314 MemRRow314 MemRCol314 10000.000000
R1315 MemRRow315 MemRCol315 10000.000000
R1316 MemRRow316 MemRCol316 10000.000000
R1317 MemRRow317 MemRCol317 10000.000000
R1318 MemRRow318 MemRCol318 10000.000000
R1319 MemRRow319 MemRCol319 10000.000000
R13110 MemRRow3110 MemRCol3110 10000.000000
R13111 MemRRow3111 MemRCol3111 10000.000000
R13112 MemRRow3112 MemRCol3112 10000.000000
R13113 MemRRow3113 MemRCol3113 10000.000000
R13114 MemRRow3114 MemRCol3114 10000.000000
R13115 MemRRow3115 MemRCol3115 10000.000000
R13116 MemRRow3116 MemRCol3116 10000.000000
R13117 MemRRow3117 MemRCol3117 10000.000000
R13118 MemRRow3118 MemRCol3118 10000.000000
R13119 MemRRow3119 MemRCol3119 10000.000000
R13120 MemRRow3120 MemRCol3120 10000.000000
R13121 MemRRow3121 MemRCol3121 10000.000000
R13122 MemRRow3122 MemRCol3122 10000.000000
R13123 MemRRow3123 MemRCol3123 10000.000000
R13124 MemRRow3124 MemRCol3124 10000.000000
R13125 MemRRow3125 MemRCol3125 10000.000000
R13126 MemRRow3126 MemRCol3126 10000.000000
R13127 MemRRow3127 MemRCol3127 10000.000000
R13128 MemRRow3128 MemRCol3128 10000.000000
R13129 MemRRow3129 MemRCol3129 10000.000000
R13130 MemRRow3130 MemRCol3130 10000.000000
R13131 MemRRow3131 MemRCol3131 10000.000000
R13132 MemRRow3132 MemRCol3132 10000.000000
R13133 MemRRow3133 MemRCol3133 10000.000000
R13134 MemRRow3134 MemRCol3134 10000.000000
R13135 MemRRow3135 MemRCol3135 10000.000000
R13136 MemRRow3136 MemRCol3136 10000.000000
R13137 MemRRow3137 MemRCol3137 10000.000000
R13138 MemRRow3138 MemRCol3138 10000.000000
R13139 MemRRow3139 MemRCol3139 10000.000000
R13140 MemRRow3140 MemRCol3140 10000.000000
R13141 MemRRow3141 MemRCol3141 10000.000000
R13142 MemRRow3142 MemRCol3142 10000.000000
R13143 MemRRow3143 MemRCol3143 10000.000000
R13144 MemRRow3144 MemRCol3144 10000.000000
R13145 MemRRow3145 MemRCol3145 10000.000000
R13146 MemRRow3146 MemRCol3146 10000.000000
R13147 MemRRow3147 MemRCol3147 10000.000000
R13148 MemRRow3148 MemRCol3148 10000.000000
R13149 MemRRow3149 MemRCol3149 10000.000000
R13150 MemRRow3150 MemRCol3150 10000.000000
R1321 MemRRow321 MemRCol321 10000.000000
R1322 MemRRow322 MemRCol322 10000.000000
R1323 MemRRow323 MemRCol323 10000.000000
R1324 MemRRow324 MemRCol324 10000.000000
R1325 MemRRow325 MemRCol325 10000.000000
R1326 MemRRow326 MemRCol326 10000.000000
R1327 MemRRow327 MemRCol327 10000.000000
R1328 MemRRow328 MemRCol328 10000.000000
R1329 MemRRow329 MemRCol329 10000.000000
R13210 MemRRow3210 MemRCol3210 10000.000000
R13211 MemRRow3211 MemRCol3211 10000.000000
R13212 MemRRow3212 MemRCol3212 10000.000000
R13213 MemRRow3213 MemRCol3213 10000.000000
R13214 MemRRow3214 MemRCol3214 10000.000000
R13215 MemRRow3215 MemRCol3215 10000.000000
R13216 MemRRow3216 MemRCol3216 10000.000000
R13217 MemRRow3217 MemRCol3217 10000.000000
R13218 MemRRow3218 MemRCol3218 10000.000000
R13219 MemRRow3219 MemRCol3219 10000.000000
R13220 MemRRow3220 MemRCol3220 10000.000000
R13221 MemRRow3221 MemRCol3221 10000.000000
R13222 MemRRow3222 MemRCol3222 10000.000000
R13223 MemRRow3223 MemRCol3223 10000.000000
R13224 MemRRow3224 MemRCol3224 10000.000000
R13225 MemRRow3225 MemRCol3225 10000.000000
R13226 MemRRow3226 MemRCol3226 10000.000000
R13227 MemRRow3227 MemRCol3227 10000.000000
R13228 MemRRow3228 MemRCol3228 10000.000000
R13229 MemRRow3229 MemRCol3229 10000.000000
R13230 MemRRow3230 MemRCol3230 10000.000000
R13231 MemRRow3231 MemRCol3231 10000.000000
R13232 MemRRow3232 MemRCol3232 10000.000000
R13233 MemRRow3233 MemRCol3233 10000.000000
R13234 MemRRow3234 MemRCol3234 10000.000000
R13235 MemRRow3235 MemRCol3235 10000.000000
R13236 MemRRow3236 MemRCol3236 10000.000000
R13237 MemRRow3237 MemRCol3237 10000.000000
R13238 MemRRow3238 MemRCol3238 10000.000000
R13239 MemRRow3239 MemRCol3239 10000.000000
R13240 MemRRow3240 MemRCol3240 10000.000000
R13241 MemRRow3241 MemRCol3241 10000.000000
R13242 MemRRow3242 MemRCol3242 10000.000000
R13243 MemRRow3243 MemRCol3243 10000.000000
R13244 MemRRow3244 MemRCol3244 10000.000000
R13245 MemRRow3245 MemRCol3245 10000.000000
R13246 MemRRow3246 MemRCol3246 10000.000000
R13247 MemRRow3247 MemRCol3247 10000.000000
R13248 MemRRow3248 MemRCol3248 10000.000000
R13249 MemRRow3249 MemRCol3249 10000.000000
R13250 MemRRow3250 MemRCol3250 10000.000000
R1331 MemRRow331 MemRCol331 10000.000000
R1332 MemRRow332 MemRCol332 10000.000000
R1333 MemRRow333 MemRCol333 10000.000000
R1334 MemRRow334 MemRCol334 10000.000000
R1335 MemRRow335 MemRCol335 10000.000000
R1336 MemRRow336 MemRCol336 10000.000000
R1337 MemRRow337 MemRCol337 10000.000000
R1338 MemRRow338 MemRCol338 10000.000000
R1339 MemRRow339 MemRCol339 10000.000000
R13310 MemRRow3310 MemRCol3310 10000.000000
R13311 MemRRow3311 MemRCol3311 10000.000000
R13312 MemRRow3312 MemRCol3312 10000.000000
R13313 MemRRow3313 MemRCol3313 10000.000000
R13314 MemRRow3314 MemRCol3314 10000.000000
R13315 MemRRow3315 MemRCol3315 10000.000000
R13316 MemRRow3316 MemRCol3316 10000.000000
R13317 MemRRow3317 MemRCol3317 10000.000000
R13318 MemRRow3318 MemRCol3318 10000.000000
R13319 MemRRow3319 MemRCol3319 10000.000000
R13320 MemRRow3320 MemRCol3320 10000.000000
R13321 MemRRow3321 MemRCol3321 10000.000000
R13322 MemRRow3322 MemRCol3322 10000.000000
R13323 MemRRow3323 MemRCol3323 10000.000000
R13324 MemRRow3324 MemRCol3324 10000.000000
R13325 MemRRow3325 MemRCol3325 10000.000000
R13326 MemRRow3326 MemRCol3326 10000.000000
R13327 MemRRow3327 MemRCol3327 10000.000000
R13328 MemRRow3328 MemRCol3328 10000.000000
R13329 MemRRow3329 MemRCol3329 10000.000000
R13330 MemRRow3330 MemRCol3330 10000.000000
R13331 MemRRow3331 MemRCol3331 10000.000000
R13332 MemRRow3332 MemRCol3332 10000.000000
R13333 MemRRow3333 MemRCol3333 10000.000000
R13334 MemRRow3334 MemRCol3334 10000.000000
R13335 MemRRow3335 MemRCol3335 10000.000000
R13336 MemRRow3336 MemRCol3336 10000.000000
R13337 MemRRow3337 MemRCol3337 10000.000000
R13338 MemRRow3338 MemRCol3338 10000.000000
R13339 MemRRow3339 MemRCol3339 10000.000000
R13340 MemRRow3340 MemRCol3340 10000.000000
R13341 MemRRow3341 MemRCol3341 10000.000000
R13342 MemRRow3342 MemRCol3342 10000.000000
R13343 MemRRow3343 MemRCol3343 10000.000000
R13344 MemRRow3344 MemRCol3344 10000.000000
R13345 MemRRow3345 MemRCol3345 10000.000000
R13346 MemRRow3346 MemRCol3346 10000.000000
R13347 MemRRow3347 MemRCol3347 10000.000000
R13348 MemRRow3348 MemRCol3348 10000.000000
R13349 MemRRow3349 MemRCol3349 10000.000000
R13350 MemRRow3350 MemRCol3350 10000.000000
R1341 MemRRow341 MemRCol341 10000.000000
R1342 MemRRow342 MemRCol342 10000.000000
R1343 MemRRow343 MemRCol343 10000.000000
R1344 MemRRow344 MemRCol344 10000.000000
R1345 MemRRow345 MemRCol345 10000.000000
R1346 MemRRow346 MemRCol346 10000.000000
R1347 MemRRow347 MemRCol347 10000.000000
R1348 MemRRow348 MemRCol348 10000.000000
R1349 MemRRow349 MemRCol349 10000.000000
R13410 MemRRow3410 MemRCol3410 10000.000000
R13411 MemRRow3411 MemRCol3411 10000.000000
R13412 MemRRow3412 MemRCol3412 10000.000000
R13413 MemRRow3413 MemRCol3413 10000.000000
R13414 MemRRow3414 MemRCol3414 10000.000000
R13415 MemRRow3415 MemRCol3415 10000.000000
R13416 MemRRow3416 MemRCol3416 10000.000000
R13417 MemRRow3417 MemRCol3417 10000.000000
R13418 MemRRow3418 MemRCol3418 10000.000000
R13419 MemRRow3419 MemRCol3419 10000.000000
R13420 MemRRow3420 MemRCol3420 10000.000000
R13421 MemRRow3421 MemRCol3421 10000.000000
R13422 MemRRow3422 MemRCol3422 10000.000000
R13423 MemRRow3423 MemRCol3423 10000.000000
R13424 MemRRow3424 MemRCol3424 10000.000000
R13425 MemRRow3425 MemRCol3425 10000.000000
R13426 MemRRow3426 MemRCol3426 10000.000000
R13427 MemRRow3427 MemRCol3427 10000.000000
R13428 MemRRow3428 MemRCol3428 10000.000000
R13429 MemRRow3429 MemRCol3429 10000.000000
R13430 MemRRow3430 MemRCol3430 10000.000000
R13431 MemRRow3431 MemRCol3431 10000.000000
R13432 MemRRow3432 MemRCol3432 10000.000000
R13433 MemRRow3433 MemRCol3433 10000.000000
R13434 MemRRow3434 MemRCol3434 10000.000000
R13435 MemRRow3435 MemRCol3435 10000.000000
R13436 MemRRow3436 MemRCol3436 10000.000000
R13437 MemRRow3437 MemRCol3437 10000.000000
R13438 MemRRow3438 MemRCol3438 10000.000000
R13439 MemRRow3439 MemRCol3439 10000.000000
R13440 MemRRow3440 MemRCol3440 10000.000000
R13441 MemRRow3441 MemRCol3441 10000.000000
R13442 MemRRow3442 MemRCol3442 10000.000000
R13443 MemRRow3443 MemRCol3443 10000.000000
R13444 MemRRow3444 MemRCol3444 10000.000000
R13445 MemRRow3445 MemRCol3445 10000.000000
R13446 MemRRow3446 MemRCol3446 10000.000000
R13447 MemRRow3447 MemRCol3447 10000.000000
R13448 MemRRow3448 MemRCol3448 10000.000000
R13449 MemRRow3449 MemRCol3449 10000.000000
R13450 MemRRow3450 MemRCol3450 10000.000000
R1351 MemRRow351 MemRCol351 10000.000000
R1352 MemRRow352 MemRCol352 10000.000000
R1353 MemRRow353 MemRCol353 10000.000000
R1354 MemRRow354 MemRCol354 10000.000000
R1355 MemRRow355 MemRCol355 10000.000000
R1356 MemRRow356 MemRCol356 10000.000000
R1357 MemRRow357 MemRCol357 10000.000000
R1358 MemRRow358 MemRCol358 10000.000000
R1359 MemRRow359 MemRCol359 10000.000000
R13510 MemRRow3510 MemRCol3510 10000.000000
R13511 MemRRow3511 MemRCol3511 10000.000000
R13512 MemRRow3512 MemRCol3512 10000.000000
R13513 MemRRow3513 MemRCol3513 10000.000000
R13514 MemRRow3514 MemRCol3514 10000.000000
R13515 MemRRow3515 MemRCol3515 10000.000000
R13516 MemRRow3516 MemRCol3516 10000.000000
R13517 MemRRow3517 MemRCol3517 10000.000000
R13518 MemRRow3518 MemRCol3518 10000.000000
R13519 MemRRow3519 MemRCol3519 10000.000000
R13520 MemRRow3520 MemRCol3520 10000.000000
R13521 MemRRow3521 MemRCol3521 10000.000000
R13522 MemRRow3522 MemRCol3522 10000.000000
R13523 MemRRow3523 MemRCol3523 10000.000000
R13524 MemRRow3524 MemRCol3524 10000.000000
R13525 MemRRow3525 MemRCol3525 10000.000000
R13526 MemRRow3526 MemRCol3526 10000.000000
R13527 MemRRow3527 MemRCol3527 10000.000000
R13528 MemRRow3528 MemRCol3528 10000.000000
R13529 MemRRow3529 MemRCol3529 10000.000000
R13530 MemRRow3530 MemRCol3530 10000.000000
R13531 MemRRow3531 MemRCol3531 10000.000000
R13532 MemRRow3532 MemRCol3532 10000.000000
R13533 MemRRow3533 MemRCol3533 10000.000000
R13534 MemRRow3534 MemRCol3534 10000.000000
R13535 MemRRow3535 MemRCol3535 10000.000000
R13536 MemRRow3536 MemRCol3536 10000.000000
R13537 MemRRow3537 MemRCol3537 10000.000000
R13538 MemRRow3538 MemRCol3538 10000.000000
R13539 MemRRow3539 MemRCol3539 10000.000000
R13540 MemRRow3540 MemRCol3540 10000.000000
R13541 MemRRow3541 MemRCol3541 10000.000000
R13542 MemRRow3542 MemRCol3542 10000.000000
R13543 MemRRow3543 MemRCol3543 10000.000000
R13544 MemRRow3544 MemRCol3544 10000.000000
R13545 MemRRow3545 MemRCol3545 10000.000000
R13546 MemRRow3546 MemRCol3546 10000.000000
R13547 MemRRow3547 MemRCol3547 10000.000000
R13548 MemRRow3548 MemRCol3548 10000.000000
R13549 MemRRow3549 MemRCol3549 10000.000000
R13550 MemRRow3550 MemRCol3550 10000.000000
R1361 MemRRow361 MemRCol361 10000.000000
R1362 MemRRow362 MemRCol362 10000.000000
R1363 MemRRow363 MemRCol363 10000.000000
R1364 MemRRow364 MemRCol364 10000.000000
R1365 MemRRow365 MemRCol365 10000.000000
R1366 MemRRow366 MemRCol366 10000.000000
R1367 MemRRow367 MemRCol367 10000.000000
R1368 MemRRow368 MemRCol368 10000.000000
R1369 MemRRow369 MemRCol369 10000.000000
R13610 MemRRow3610 MemRCol3610 10000.000000
R13611 MemRRow3611 MemRCol3611 10000.000000
R13612 MemRRow3612 MemRCol3612 10000.000000
R13613 MemRRow3613 MemRCol3613 10000.000000
R13614 MemRRow3614 MemRCol3614 10000.000000
R13615 MemRRow3615 MemRCol3615 10000.000000
R13616 MemRRow3616 MemRCol3616 10000.000000
R13617 MemRRow3617 MemRCol3617 10000.000000
R13618 MemRRow3618 MemRCol3618 10000.000000
R13619 MemRRow3619 MemRCol3619 10000.000000
R13620 MemRRow3620 MemRCol3620 10000.000000
R13621 MemRRow3621 MemRCol3621 10000.000000
R13622 MemRRow3622 MemRCol3622 10000.000000
R13623 MemRRow3623 MemRCol3623 10000.000000
R13624 MemRRow3624 MemRCol3624 10000.000000
R13625 MemRRow3625 MemRCol3625 10000.000000
R13626 MemRRow3626 MemRCol3626 10000.000000
R13627 MemRRow3627 MemRCol3627 10000.000000
R13628 MemRRow3628 MemRCol3628 10000.000000
R13629 MemRRow3629 MemRCol3629 10000.000000
R13630 MemRRow3630 MemRCol3630 10000.000000
R13631 MemRRow3631 MemRCol3631 10000.000000
R13632 MemRRow3632 MemRCol3632 10000.000000
R13633 MemRRow3633 MemRCol3633 10000.000000
R13634 MemRRow3634 MemRCol3634 10000.000000
R13635 MemRRow3635 MemRCol3635 10000.000000
R13636 MemRRow3636 MemRCol3636 10000.000000
R13637 MemRRow3637 MemRCol3637 10000.000000
R13638 MemRRow3638 MemRCol3638 10000.000000
R13639 MemRRow3639 MemRCol3639 10000.000000
R13640 MemRRow3640 MemRCol3640 10000.000000
R13641 MemRRow3641 MemRCol3641 10000.000000
R13642 MemRRow3642 MemRCol3642 10000.000000
R13643 MemRRow3643 MemRCol3643 10000.000000
R13644 MemRRow3644 MemRCol3644 10000.000000
R13645 MemRRow3645 MemRCol3645 10000.000000
R13646 MemRRow3646 MemRCol3646 10000.000000
R13647 MemRRow3647 MemRCol3647 10000.000000
R13648 MemRRow3648 MemRCol3648 10000.000000
R13649 MemRRow3649 MemRCol3649 10000.000000
R13650 MemRRow3650 MemRCol3650 10000.000000
R1371 MemRRow371 MemRCol371 10000.000000
R1372 MemRRow372 MemRCol372 10000.000000
R1373 MemRRow373 MemRCol373 10000.000000
R1374 MemRRow374 MemRCol374 10000.000000
R1375 MemRRow375 MemRCol375 10000.000000
R1376 MemRRow376 MemRCol376 10000.000000
R1377 MemRRow377 MemRCol377 10000.000000
R1378 MemRRow378 MemRCol378 10000.000000
R1379 MemRRow379 MemRCol379 10000.000000
R13710 MemRRow3710 MemRCol3710 10000.000000
R13711 MemRRow3711 MemRCol3711 10000.000000
R13712 MemRRow3712 MemRCol3712 10000.000000
R13713 MemRRow3713 MemRCol3713 10000.000000
R13714 MemRRow3714 MemRCol3714 10000.000000
R13715 MemRRow3715 MemRCol3715 10000.000000
R13716 MemRRow3716 MemRCol3716 10000.000000
R13717 MemRRow3717 MemRCol3717 10000.000000
R13718 MemRRow3718 MemRCol3718 10000.000000
R13719 MemRRow3719 MemRCol3719 10000.000000
R13720 MemRRow3720 MemRCol3720 10000.000000
R13721 MemRRow3721 MemRCol3721 10000.000000
R13722 MemRRow3722 MemRCol3722 10000.000000
R13723 MemRRow3723 MemRCol3723 10000.000000
R13724 MemRRow3724 MemRCol3724 10000.000000
R13725 MemRRow3725 MemRCol3725 10000.000000
R13726 MemRRow3726 MemRCol3726 10000.000000
R13727 MemRRow3727 MemRCol3727 10000.000000
R13728 MemRRow3728 MemRCol3728 10000.000000
R13729 MemRRow3729 MemRCol3729 10000.000000
R13730 MemRRow3730 MemRCol3730 10000.000000
R13731 MemRRow3731 MemRCol3731 10000.000000
R13732 MemRRow3732 MemRCol3732 10000.000000
R13733 MemRRow3733 MemRCol3733 10000.000000
R13734 MemRRow3734 MemRCol3734 10000.000000
R13735 MemRRow3735 MemRCol3735 10000.000000
R13736 MemRRow3736 MemRCol3736 10000.000000
R13737 MemRRow3737 MemRCol3737 10000.000000
R13738 MemRRow3738 MemRCol3738 10000.000000
R13739 MemRRow3739 MemRCol3739 10000.000000
R13740 MemRRow3740 MemRCol3740 10000.000000
R13741 MemRRow3741 MemRCol3741 10000.000000
R13742 MemRRow3742 MemRCol3742 10000.000000
R13743 MemRRow3743 MemRCol3743 10000.000000
R13744 MemRRow3744 MemRCol3744 10000.000000
R13745 MemRRow3745 MemRCol3745 10000.000000
R13746 MemRRow3746 MemRCol3746 10000.000000
R13747 MemRRow3747 MemRCol3747 10000.000000
R13748 MemRRow3748 MemRCol3748 10000.000000
R13749 MemRRow3749 MemRCol3749 10000.000000
R13750 MemRRow3750 MemRCol3750 10000.000000
R1381 MemRRow381 MemRCol381 10000.000000
R1382 MemRRow382 MemRCol382 10000.000000
R1383 MemRRow383 MemRCol383 10000.000000
R1384 MemRRow384 MemRCol384 10000.000000
R1385 MemRRow385 MemRCol385 10000.000000
R1386 MemRRow386 MemRCol386 10000.000000
R1387 MemRRow387 MemRCol387 10000.000000
R1388 MemRRow388 MemRCol388 10000.000000
R1389 MemRRow389 MemRCol389 10000.000000
R13810 MemRRow3810 MemRCol3810 10000.000000
R13811 MemRRow3811 MemRCol3811 10000.000000
R13812 MemRRow3812 MemRCol3812 10000.000000
R13813 MemRRow3813 MemRCol3813 10000.000000
R13814 MemRRow3814 MemRCol3814 10000.000000
R13815 MemRRow3815 MemRCol3815 10000.000000
R13816 MemRRow3816 MemRCol3816 10000.000000
R13817 MemRRow3817 MemRCol3817 10000.000000
R13818 MemRRow3818 MemRCol3818 10000.000000
R13819 MemRRow3819 MemRCol3819 10000.000000
R13820 MemRRow3820 MemRCol3820 10000.000000
R13821 MemRRow3821 MemRCol3821 10000.000000
R13822 MemRRow3822 MemRCol3822 10000.000000
R13823 MemRRow3823 MemRCol3823 10000.000000
R13824 MemRRow3824 MemRCol3824 10000.000000
R13825 MemRRow3825 MemRCol3825 10000.000000
R13826 MemRRow3826 MemRCol3826 10000.000000
R13827 MemRRow3827 MemRCol3827 10000.000000
R13828 MemRRow3828 MemRCol3828 10000.000000
R13829 MemRRow3829 MemRCol3829 10000.000000
R13830 MemRRow3830 MemRCol3830 10000.000000
R13831 MemRRow3831 MemRCol3831 10000.000000
R13832 MemRRow3832 MemRCol3832 10000.000000
R13833 MemRRow3833 MemRCol3833 10000.000000
R13834 MemRRow3834 MemRCol3834 10000.000000
R13835 MemRRow3835 MemRCol3835 10000.000000
R13836 MemRRow3836 MemRCol3836 10000.000000
R13837 MemRRow3837 MemRCol3837 10000.000000
R13838 MemRRow3838 MemRCol3838 10000.000000
R13839 MemRRow3839 MemRCol3839 10000.000000
R13840 MemRRow3840 MemRCol3840 10000.000000
R13841 MemRRow3841 MemRCol3841 10000.000000
R13842 MemRRow3842 MemRCol3842 10000.000000
R13843 MemRRow3843 MemRCol3843 10000.000000
R13844 MemRRow3844 MemRCol3844 10000.000000
R13845 MemRRow3845 MemRCol3845 10000.000000
R13846 MemRRow3846 MemRCol3846 10000.000000
R13847 MemRRow3847 MemRCol3847 10000.000000
R13848 MemRRow3848 MemRCol3848 10000.000000
R13849 MemRRow3849 MemRCol3849 10000.000000
R13850 MemRRow3850 MemRCol3850 10000.000000
R1391 MemRRow391 MemRCol391 10000.000000
R1392 MemRRow392 MemRCol392 10000.000000
R1393 MemRRow393 MemRCol393 10000.000000
R1394 MemRRow394 MemRCol394 10000.000000
R1395 MemRRow395 MemRCol395 10000.000000
R1396 MemRRow396 MemRCol396 10000.000000
R1397 MemRRow397 MemRCol397 10000.000000
R1398 MemRRow398 MemRCol398 10000.000000
R1399 MemRRow399 MemRCol399 10000.000000
R13910 MemRRow3910 MemRCol3910 10000.000000
R13911 MemRRow3911 MemRCol3911 10000.000000
R13912 MemRRow3912 MemRCol3912 10000.000000
R13913 MemRRow3913 MemRCol3913 10000.000000
R13914 MemRRow3914 MemRCol3914 10000.000000
R13915 MemRRow3915 MemRCol3915 10000.000000
R13916 MemRRow3916 MemRCol3916 10000.000000
R13917 MemRRow3917 MemRCol3917 10000.000000
R13918 MemRRow3918 MemRCol3918 10000.000000
R13919 MemRRow3919 MemRCol3919 10000.000000
R13920 MemRRow3920 MemRCol3920 10000.000000
R13921 MemRRow3921 MemRCol3921 10000.000000
R13922 MemRRow3922 MemRCol3922 10000.000000
R13923 MemRRow3923 MemRCol3923 10000.000000
R13924 MemRRow3924 MemRCol3924 10000.000000
R13925 MemRRow3925 MemRCol3925 10000.000000
R13926 MemRRow3926 MemRCol3926 10000.000000
R13927 MemRRow3927 MemRCol3927 10000.000000
R13928 MemRRow3928 MemRCol3928 10000.000000
R13929 MemRRow3929 MemRCol3929 10000.000000
R13930 MemRRow3930 MemRCol3930 10000.000000
R13931 MemRRow3931 MemRCol3931 10000.000000
R13932 MemRRow3932 MemRCol3932 10000.000000
R13933 MemRRow3933 MemRCol3933 10000.000000
R13934 MemRRow3934 MemRCol3934 10000.000000
R13935 MemRRow3935 MemRCol3935 10000.000000
R13936 MemRRow3936 MemRCol3936 10000.000000
R13937 MemRRow3937 MemRCol3937 10000.000000
R13938 MemRRow3938 MemRCol3938 10000.000000
R13939 MemRRow3939 MemRCol3939 10000.000000
R13940 MemRRow3940 MemRCol3940 10000.000000
R13941 MemRRow3941 MemRCol3941 10000.000000
R13942 MemRRow3942 MemRCol3942 10000.000000
R13943 MemRRow3943 MemRCol3943 10000.000000
R13944 MemRRow3944 MemRCol3944 10000.000000
R13945 MemRRow3945 MemRCol3945 10000.000000
R13946 MemRRow3946 MemRCol3946 10000.000000
R13947 MemRRow3947 MemRCol3947 10000.000000
R13948 MemRRow3948 MemRCol3948 10000.000000
R13949 MemRRow3949 MemRCol3949 10000.000000
R13950 MemRRow3950 MemRCol3950 10000.000000
R1401 MemRRow401 MemRCol401 10000.000000
R1402 MemRRow402 MemRCol402 10000.000000
R1403 MemRRow403 MemRCol403 10000.000000
R1404 MemRRow404 MemRCol404 10000.000000
R1405 MemRRow405 MemRCol405 10000.000000
R1406 MemRRow406 MemRCol406 10000.000000
R1407 MemRRow407 MemRCol407 10000.000000
R1408 MemRRow408 MemRCol408 10000.000000
R1409 MemRRow409 MemRCol409 10000.000000
R14010 MemRRow4010 MemRCol4010 10000.000000
R14011 MemRRow4011 MemRCol4011 10000.000000
R14012 MemRRow4012 MemRCol4012 10000.000000
R14013 MemRRow4013 MemRCol4013 10000.000000
R14014 MemRRow4014 MemRCol4014 10000.000000
R14015 MemRRow4015 MemRCol4015 10000.000000
R14016 MemRRow4016 MemRCol4016 10000.000000
R14017 MemRRow4017 MemRCol4017 10000.000000
R14018 MemRRow4018 MemRCol4018 10000.000000
R14019 MemRRow4019 MemRCol4019 10000.000000
R14020 MemRRow4020 MemRCol4020 10000.000000
R14021 MemRRow4021 MemRCol4021 10000.000000
R14022 MemRRow4022 MemRCol4022 10000.000000
R14023 MemRRow4023 MemRCol4023 10000.000000
R14024 MemRRow4024 MemRCol4024 10000.000000
R14025 MemRRow4025 MemRCol4025 10000.000000
R14026 MemRRow4026 MemRCol4026 10000.000000
R14027 MemRRow4027 MemRCol4027 10000.000000
R14028 MemRRow4028 MemRCol4028 10000.000000
R14029 MemRRow4029 MemRCol4029 10000.000000
R14030 MemRRow4030 MemRCol4030 10000.000000
R14031 MemRRow4031 MemRCol4031 10000.000000
R14032 MemRRow4032 MemRCol4032 10000.000000
R14033 MemRRow4033 MemRCol4033 10000.000000
R14034 MemRRow4034 MemRCol4034 10000.000000
R14035 MemRRow4035 MemRCol4035 10000.000000
R14036 MemRRow4036 MemRCol4036 10000.000000
R14037 MemRRow4037 MemRCol4037 10000.000000
R14038 MemRRow4038 MemRCol4038 10000.000000
R14039 MemRRow4039 MemRCol4039 10000.000000
R14040 MemRRow4040 MemRCol4040 10000.000000
R14041 MemRRow4041 MemRCol4041 10000.000000
R14042 MemRRow4042 MemRCol4042 10000.000000
R14043 MemRRow4043 MemRCol4043 10000.000000
R14044 MemRRow4044 MemRCol4044 10000.000000
R14045 MemRRow4045 MemRCol4045 10000.000000
R14046 MemRRow4046 MemRCol4046 10000.000000
R14047 MemRRow4047 MemRCol4047 10000.000000
R14048 MemRRow4048 MemRCol4048 10000.000000
R14049 MemRRow4049 MemRCol4049 10000.000000
R14050 MemRRow4050 MemRCol4050 10000.000000
R1411 MemRRow411 MemRCol411 10000.000000
R1412 MemRRow412 MemRCol412 10000.000000
R1413 MemRRow413 MemRCol413 10000.000000
R1414 MemRRow414 MemRCol414 10000.000000
R1415 MemRRow415 MemRCol415 10000.000000
R1416 MemRRow416 MemRCol416 10000.000000
R1417 MemRRow417 MemRCol417 10000.000000
R1418 MemRRow418 MemRCol418 10000.000000
R1419 MemRRow419 MemRCol419 10000.000000
R14110 MemRRow4110 MemRCol4110 10000.000000
R14111 MemRRow4111 MemRCol4111 10000.000000
R14112 MemRRow4112 MemRCol4112 10000.000000
R14113 MemRRow4113 MemRCol4113 10000.000000
R14114 MemRRow4114 MemRCol4114 10000.000000
R14115 MemRRow4115 MemRCol4115 10000.000000
R14116 MemRRow4116 MemRCol4116 10000.000000
R14117 MemRRow4117 MemRCol4117 10000.000000
R14118 MemRRow4118 MemRCol4118 10000.000000
R14119 MemRRow4119 MemRCol4119 10000.000000
R14120 MemRRow4120 MemRCol4120 10000.000000
R14121 MemRRow4121 MemRCol4121 10000.000000
R14122 MemRRow4122 MemRCol4122 10000.000000
R14123 MemRRow4123 MemRCol4123 10000.000000
R14124 MemRRow4124 MemRCol4124 10000.000000
R14125 MemRRow4125 MemRCol4125 10000.000000
R14126 MemRRow4126 MemRCol4126 10000.000000
R14127 MemRRow4127 MemRCol4127 10000.000000
R14128 MemRRow4128 MemRCol4128 10000.000000
R14129 MemRRow4129 MemRCol4129 10000.000000
R14130 MemRRow4130 MemRCol4130 10000.000000
R14131 MemRRow4131 MemRCol4131 10000.000000
R14132 MemRRow4132 MemRCol4132 10000.000000
R14133 MemRRow4133 MemRCol4133 10000.000000
R14134 MemRRow4134 MemRCol4134 10000.000000
R14135 MemRRow4135 MemRCol4135 10000.000000
R14136 MemRRow4136 MemRCol4136 10000.000000
R14137 MemRRow4137 MemRCol4137 10000.000000
R14138 MemRRow4138 MemRCol4138 10000.000000
R14139 MemRRow4139 MemRCol4139 10000.000000
R14140 MemRRow4140 MemRCol4140 10000.000000
R14141 MemRRow4141 MemRCol4141 10000.000000
R14142 MemRRow4142 MemRCol4142 10000.000000
R14143 MemRRow4143 MemRCol4143 10000.000000
R14144 MemRRow4144 MemRCol4144 10000.000000
R14145 MemRRow4145 MemRCol4145 10000.000000
R14146 MemRRow4146 MemRCol4146 10000.000000
R14147 MemRRow4147 MemRCol4147 10000.000000
R14148 MemRRow4148 MemRCol4148 10000.000000
R14149 MemRRow4149 MemRCol4149 10000.000000
R14150 MemRRow4150 MemRCol4150 10000.000000
R1421 MemRRow421 MemRCol421 10000.000000
R1422 MemRRow422 MemRCol422 10000.000000
R1423 MemRRow423 MemRCol423 10000.000000
R1424 MemRRow424 MemRCol424 10000.000000
R1425 MemRRow425 MemRCol425 10000.000000
R1426 MemRRow426 MemRCol426 10000.000000
R1427 MemRRow427 MemRCol427 10000.000000
R1428 MemRRow428 MemRCol428 10000.000000
R1429 MemRRow429 MemRCol429 10000.000000
R14210 MemRRow4210 MemRCol4210 10000.000000
R14211 MemRRow4211 MemRCol4211 10000.000000
R14212 MemRRow4212 MemRCol4212 10000.000000
R14213 MemRRow4213 MemRCol4213 10000.000000
R14214 MemRRow4214 MemRCol4214 10000.000000
R14215 MemRRow4215 MemRCol4215 10000.000000
R14216 MemRRow4216 MemRCol4216 10000.000000
R14217 MemRRow4217 MemRCol4217 10000.000000
R14218 MemRRow4218 MemRCol4218 10000.000000
R14219 MemRRow4219 MemRCol4219 10000.000000
R14220 MemRRow4220 MemRCol4220 10000.000000
R14221 MemRRow4221 MemRCol4221 10000.000000
R14222 MemRRow4222 MemRCol4222 10000.000000
R14223 MemRRow4223 MemRCol4223 10000.000000
R14224 MemRRow4224 MemRCol4224 10000.000000
R14225 MemRRow4225 MemRCol4225 10000.000000
R14226 MemRRow4226 MemRCol4226 10000.000000
R14227 MemRRow4227 MemRCol4227 10000.000000
R14228 MemRRow4228 MemRCol4228 10000.000000
R14229 MemRRow4229 MemRCol4229 10000.000000
R14230 MemRRow4230 MemRCol4230 10000.000000
R14231 MemRRow4231 MemRCol4231 10000.000000
R14232 MemRRow4232 MemRCol4232 10000.000000
R14233 MemRRow4233 MemRCol4233 10000.000000
R14234 MemRRow4234 MemRCol4234 10000.000000
R14235 MemRRow4235 MemRCol4235 10000.000000
R14236 MemRRow4236 MemRCol4236 10000.000000
R14237 MemRRow4237 MemRCol4237 10000.000000
R14238 MemRRow4238 MemRCol4238 10000.000000
R14239 MemRRow4239 MemRCol4239 10000.000000
R14240 MemRRow4240 MemRCol4240 10000.000000
R14241 MemRRow4241 MemRCol4241 10000.000000
R14242 MemRRow4242 MemRCol4242 10000.000000
R14243 MemRRow4243 MemRCol4243 10000.000000
R14244 MemRRow4244 MemRCol4244 10000.000000
R14245 MemRRow4245 MemRCol4245 10000.000000
R14246 MemRRow4246 MemRCol4246 10000.000000
R14247 MemRRow4247 MemRCol4247 10000.000000
R14248 MemRRow4248 MemRCol4248 10000.000000
R14249 MemRRow4249 MemRCol4249 10000.000000
R14250 MemRRow4250 MemRCol4250 10000.000000
R1431 MemRRow431 MemRCol431 10000.000000
R1432 MemRRow432 MemRCol432 10000.000000
R1433 MemRRow433 MemRCol433 10000.000000
R1434 MemRRow434 MemRCol434 10000.000000
R1435 MemRRow435 MemRCol435 10000.000000
R1436 MemRRow436 MemRCol436 10000.000000
R1437 MemRRow437 MemRCol437 10000.000000
R1438 MemRRow438 MemRCol438 10000.000000
R1439 MemRRow439 MemRCol439 10000.000000
R14310 MemRRow4310 MemRCol4310 10000.000000
R14311 MemRRow4311 MemRCol4311 10000.000000
R14312 MemRRow4312 MemRCol4312 10000.000000
R14313 MemRRow4313 MemRCol4313 10000.000000
R14314 MemRRow4314 MemRCol4314 10000.000000
R14315 MemRRow4315 MemRCol4315 10000.000000
R14316 MemRRow4316 MemRCol4316 10000.000000
R14317 MemRRow4317 MemRCol4317 10000.000000
R14318 MemRRow4318 MemRCol4318 10000.000000
R14319 MemRRow4319 MemRCol4319 10000.000000
R14320 MemRRow4320 MemRCol4320 10000.000000
R14321 MemRRow4321 MemRCol4321 10000.000000
R14322 MemRRow4322 MemRCol4322 10000.000000
R14323 MemRRow4323 MemRCol4323 10000.000000
R14324 MemRRow4324 MemRCol4324 10000.000000
R14325 MemRRow4325 MemRCol4325 10000.000000
R14326 MemRRow4326 MemRCol4326 10000.000000
R14327 MemRRow4327 MemRCol4327 10000.000000
R14328 MemRRow4328 MemRCol4328 10000.000000
R14329 MemRRow4329 MemRCol4329 10000.000000
R14330 MemRRow4330 MemRCol4330 10000.000000
R14331 MemRRow4331 MemRCol4331 10000.000000
R14332 MemRRow4332 MemRCol4332 10000.000000
R14333 MemRRow4333 MemRCol4333 10000.000000
R14334 MemRRow4334 MemRCol4334 10000.000000
R14335 MemRRow4335 MemRCol4335 10000.000000
R14336 MemRRow4336 MemRCol4336 10000.000000
R14337 MemRRow4337 MemRCol4337 10000.000000
R14338 MemRRow4338 MemRCol4338 10000.000000
R14339 MemRRow4339 MemRCol4339 10000.000000
R14340 MemRRow4340 MemRCol4340 10000.000000
R14341 MemRRow4341 MemRCol4341 10000.000000
R14342 MemRRow4342 MemRCol4342 10000.000000
R14343 MemRRow4343 MemRCol4343 10000.000000
R14344 MemRRow4344 MemRCol4344 10000.000000
R14345 MemRRow4345 MemRCol4345 10000.000000
R14346 MemRRow4346 MemRCol4346 10000.000000
R14347 MemRRow4347 MemRCol4347 10000.000000
R14348 MemRRow4348 MemRCol4348 10000.000000
R14349 MemRRow4349 MemRCol4349 10000.000000
R14350 MemRRow4350 MemRCol4350 10000.000000
R1441 MemRRow441 MemRCol441 10000.000000
R1442 MemRRow442 MemRCol442 10000.000000
R1443 MemRRow443 MemRCol443 10000.000000
R1444 MemRRow444 MemRCol444 10000.000000
R1445 MemRRow445 MemRCol445 10000.000000
R1446 MemRRow446 MemRCol446 10000.000000
R1447 MemRRow447 MemRCol447 10000.000000
R1448 MemRRow448 MemRCol448 10000.000000
R1449 MemRRow449 MemRCol449 10000.000000
R14410 MemRRow4410 MemRCol4410 10000.000000
R14411 MemRRow4411 MemRCol4411 10000.000000
R14412 MemRRow4412 MemRCol4412 10000.000000
R14413 MemRRow4413 MemRCol4413 10000.000000
R14414 MemRRow4414 MemRCol4414 10000.000000
R14415 MemRRow4415 MemRCol4415 10000.000000
R14416 MemRRow4416 MemRCol4416 10000.000000
R14417 MemRRow4417 MemRCol4417 10000.000000
R14418 MemRRow4418 MemRCol4418 10000.000000
R14419 MemRRow4419 MemRCol4419 10000.000000
R14420 MemRRow4420 MemRCol4420 10000.000000
R14421 MemRRow4421 MemRCol4421 10000.000000
R14422 MemRRow4422 MemRCol4422 10000.000000
R14423 MemRRow4423 MemRCol4423 10000.000000
R14424 MemRRow4424 MemRCol4424 10000.000000
R14425 MemRRow4425 MemRCol4425 10000.000000
R14426 MemRRow4426 MemRCol4426 10000.000000
R14427 MemRRow4427 MemRCol4427 10000.000000
R14428 MemRRow4428 MemRCol4428 10000.000000
R14429 MemRRow4429 MemRCol4429 10000.000000
R14430 MemRRow4430 MemRCol4430 10000.000000
R14431 MemRRow4431 MemRCol4431 10000.000000
R14432 MemRRow4432 MemRCol4432 10000.000000
R14433 MemRRow4433 MemRCol4433 10000.000000
R14434 MemRRow4434 MemRCol4434 10000.000000
R14435 MemRRow4435 MemRCol4435 10000.000000
R14436 MemRRow4436 MemRCol4436 10000.000000
R14437 MemRRow4437 MemRCol4437 10000.000000
R14438 MemRRow4438 MemRCol4438 10000.000000
R14439 MemRRow4439 MemRCol4439 10000.000000
R14440 MemRRow4440 MemRCol4440 10000.000000
R14441 MemRRow4441 MemRCol4441 10000.000000
R14442 MemRRow4442 MemRCol4442 10000.000000
R14443 MemRRow4443 MemRCol4443 10000.000000
R14444 MemRRow4444 MemRCol4444 10000.000000
R14445 MemRRow4445 MemRCol4445 10000.000000
R14446 MemRRow4446 MemRCol4446 10000.000000
R14447 MemRRow4447 MemRCol4447 10000.000000
R14448 MemRRow4448 MemRCol4448 10000.000000
R14449 MemRRow4449 MemRCol4449 10000.000000
R14450 MemRRow4450 MemRCol4450 10000.000000
R1451 MemRRow451 MemRCol451 10000.000000
R1452 MemRRow452 MemRCol452 10000.000000
R1453 MemRRow453 MemRCol453 10000.000000
R1454 MemRRow454 MemRCol454 10000.000000
R1455 MemRRow455 MemRCol455 10000.000000
R1456 MemRRow456 MemRCol456 10000.000000
R1457 MemRRow457 MemRCol457 10000.000000
R1458 MemRRow458 MemRCol458 10000.000000
R1459 MemRRow459 MemRCol459 10000.000000
R14510 MemRRow4510 MemRCol4510 10000.000000
R14511 MemRRow4511 MemRCol4511 10000.000000
R14512 MemRRow4512 MemRCol4512 10000.000000
R14513 MemRRow4513 MemRCol4513 10000.000000
R14514 MemRRow4514 MemRCol4514 10000.000000
R14515 MemRRow4515 MemRCol4515 10000.000000
R14516 MemRRow4516 MemRCol4516 10000.000000
R14517 MemRRow4517 MemRCol4517 10000.000000
R14518 MemRRow4518 MemRCol4518 10000.000000
R14519 MemRRow4519 MemRCol4519 10000.000000
R14520 MemRRow4520 MemRCol4520 10000.000000
R14521 MemRRow4521 MemRCol4521 10000.000000
R14522 MemRRow4522 MemRCol4522 10000.000000
R14523 MemRRow4523 MemRCol4523 10000.000000
R14524 MemRRow4524 MemRCol4524 10000.000000
R14525 MemRRow4525 MemRCol4525 10000.000000
R14526 MemRRow4526 MemRCol4526 10000.000000
R14527 MemRRow4527 MemRCol4527 10000.000000
R14528 MemRRow4528 MemRCol4528 10000.000000
R14529 MemRRow4529 MemRCol4529 10000.000000
R14530 MemRRow4530 MemRCol4530 10000.000000
R14531 MemRRow4531 MemRCol4531 10000.000000
R14532 MemRRow4532 MemRCol4532 10000.000000
R14533 MemRRow4533 MemRCol4533 10000.000000
R14534 MemRRow4534 MemRCol4534 10000.000000
R14535 MemRRow4535 MemRCol4535 10000.000000
R14536 MemRRow4536 MemRCol4536 10000.000000
R14537 MemRRow4537 MemRCol4537 10000.000000
R14538 MemRRow4538 MemRCol4538 10000.000000
R14539 MemRRow4539 MemRCol4539 10000.000000
R14540 MemRRow4540 MemRCol4540 10000.000000
R14541 MemRRow4541 MemRCol4541 10000.000000
R14542 MemRRow4542 MemRCol4542 10000.000000
R14543 MemRRow4543 MemRCol4543 10000.000000
R14544 MemRRow4544 MemRCol4544 10000.000000
R14545 MemRRow4545 MemRCol4545 10000.000000
R14546 MemRRow4546 MemRCol4546 10000.000000
R14547 MemRRow4547 MemRCol4547 10000.000000
R14548 MemRRow4548 MemRCol4548 10000.000000
R14549 MemRRow4549 MemRCol4549 10000.000000
R14550 MemRRow4550 MemRCol4550 10000.000000
R1461 MemRRow461 MemRCol461 10000.000000
R1462 MemRRow462 MemRCol462 10000.000000
R1463 MemRRow463 MemRCol463 10000.000000
R1464 MemRRow464 MemRCol464 10000.000000
R1465 MemRRow465 MemRCol465 10000.000000
R1466 MemRRow466 MemRCol466 10000.000000
R1467 MemRRow467 MemRCol467 10000.000000
R1468 MemRRow468 MemRCol468 10000.000000
R1469 MemRRow469 MemRCol469 10000.000000
R14610 MemRRow4610 MemRCol4610 10000.000000
R14611 MemRRow4611 MemRCol4611 10000.000000
R14612 MemRRow4612 MemRCol4612 10000.000000
R14613 MemRRow4613 MemRCol4613 10000.000000
R14614 MemRRow4614 MemRCol4614 10000.000000
R14615 MemRRow4615 MemRCol4615 10000.000000
R14616 MemRRow4616 MemRCol4616 10000.000000
R14617 MemRRow4617 MemRCol4617 10000.000000
R14618 MemRRow4618 MemRCol4618 10000.000000
R14619 MemRRow4619 MemRCol4619 10000.000000
R14620 MemRRow4620 MemRCol4620 10000.000000
R14621 MemRRow4621 MemRCol4621 10000.000000
R14622 MemRRow4622 MemRCol4622 10000.000000
R14623 MemRRow4623 MemRCol4623 10000.000000
R14624 MemRRow4624 MemRCol4624 10000.000000
R14625 MemRRow4625 MemRCol4625 10000.000000
R14626 MemRRow4626 MemRCol4626 10000.000000
R14627 MemRRow4627 MemRCol4627 10000.000000
R14628 MemRRow4628 MemRCol4628 10000.000000
R14629 MemRRow4629 MemRCol4629 10000.000000
R14630 MemRRow4630 MemRCol4630 10000.000000
R14631 MemRRow4631 MemRCol4631 10000.000000
R14632 MemRRow4632 MemRCol4632 10000.000000
R14633 MemRRow4633 MemRCol4633 10000.000000
R14634 MemRRow4634 MemRCol4634 10000.000000
R14635 MemRRow4635 MemRCol4635 10000.000000
R14636 MemRRow4636 MemRCol4636 10000.000000
R14637 MemRRow4637 MemRCol4637 10000.000000
R14638 MemRRow4638 MemRCol4638 10000.000000
R14639 MemRRow4639 MemRCol4639 10000.000000
R14640 MemRRow4640 MemRCol4640 10000.000000
R14641 MemRRow4641 MemRCol4641 10000.000000
R14642 MemRRow4642 MemRCol4642 10000.000000
R14643 MemRRow4643 MemRCol4643 10000.000000
R14644 MemRRow4644 MemRCol4644 10000.000000
R14645 MemRRow4645 MemRCol4645 10000.000000
R14646 MemRRow4646 MemRCol4646 10000.000000
R14647 MemRRow4647 MemRCol4647 10000.000000
R14648 MemRRow4648 MemRCol4648 10000.000000
R14649 MemRRow4649 MemRCol4649 10000.000000
R14650 MemRRow4650 MemRCol4650 10000.000000
R1471 MemRRow471 MemRCol471 10000.000000
R1472 MemRRow472 MemRCol472 10000.000000
R1473 MemRRow473 MemRCol473 10000.000000
R1474 MemRRow474 MemRCol474 10000.000000
R1475 MemRRow475 MemRCol475 10000.000000
R1476 MemRRow476 MemRCol476 10000.000000
R1477 MemRRow477 MemRCol477 10000.000000
R1478 MemRRow478 MemRCol478 10000.000000
R1479 MemRRow479 MemRCol479 10000.000000
R14710 MemRRow4710 MemRCol4710 10000.000000
R14711 MemRRow4711 MemRCol4711 10000.000000
R14712 MemRRow4712 MemRCol4712 10000.000000
R14713 MemRRow4713 MemRCol4713 10000.000000
R14714 MemRRow4714 MemRCol4714 10000.000000
R14715 MemRRow4715 MemRCol4715 10000.000000
R14716 MemRRow4716 MemRCol4716 10000.000000
R14717 MemRRow4717 MemRCol4717 10000.000000
R14718 MemRRow4718 MemRCol4718 10000.000000
R14719 MemRRow4719 MemRCol4719 10000.000000
R14720 MemRRow4720 MemRCol4720 10000.000000
R14721 MemRRow4721 MemRCol4721 10000.000000
R14722 MemRRow4722 MemRCol4722 10000.000000
R14723 MemRRow4723 MemRCol4723 10000.000000
R14724 MemRRow4724 MemRCol4724 10000.000000
R14725 MemRRow4725 MemRCol4725 10000.000000
R14726 MemRRow4726 MemRCol4726 10000.000000
R14727 MemRRow4727 MemRCol4727 10000.000000
R14728 MemRRow4728 MemRCol4728 10000.000000
R14729 MemRRow4729 MemRCol4729 10000.000000
R14730 MemRRow4730 MemRCol4730 10000.000000
R14731 MemRRow4731 MemRCol4731 10000.000000
R14732 MemRRow4732 MemRCol4732 10000.000000
R14733 MemRRow4733 MemRCol4733 10000.000000
R14734 MemRRow4734 MemRCol4734 10000.000000
R14735 MemRRow4735 MemRCol4735 10000.000000
R14736 MemRRow4736 MemRCol4736 10000.000000
R14737 MemRRow4737 MemRCol4737 10000.000000
R14738 MemRRow4738 MemRCol4738 10000.000000
R14739 MemRRow4739 MemRCol4739 10000.000000
R14740 MemRRow4740 MemRCol4740 10000.000000
R14741 MemRRow4741 MemRCol4741 10000.000000
R14742 MemRRow4742 MemRCol4742 10000.000000
R14743 MemRRow4743 MemRCol4743 10000.000000
R14744 MemRRow4744 MemRCol4744 10000.000000
R14745 MemRRow4745 MemRCol4745 10000.000000
R14746 MemRRow4746 MemRCol4746 10000.000000
R14747 MemRRow4747 MemRCol4747 10000.000000
R14748 MemRRow4748 MemRCol4748 10000.000000
R14749 MemRRow4749 MemRCol4749 10000.000000
R14750 MemRRow4750 MemRCol4750 10000.000000
R1481 MemRRow481 MemRCol481 10000.000000
R1482 MemRRow482 MemRCol482 10000.000000
R1483 MemRRow483 MemRCol483 10000.000000
R1484 MemRRow484 MemRCol484 10000.000000
R1485 MemRRow485 MemRCol485 10000.000000
R1486 MemRRow486 MemRCol486 10000.000000
R1487 MemRRow487 MemRCol487 10000.000000
R1488 MemRRow488 MemRCol488 10000.000000
R1489 MemRRow489 MemRCol489 10000.000000
R14810 MemRRow4810 MemRCol4810 10000.000000
R14811 MemRRow4811 MemRCol4811 10000.000000
R14812 MemRRow4812 MemRCol4812 10000.000000
R14813 MemRRow4813 MemRCol4813 10000.000000
R14814 MemRRow4814 MemRCol4814 10000.000000
R14815 MemRRow4815 MemRCol4815 10000.000000
R14816 MemRRow4816 MemRCol4816 10000.000000
R14817 MemRRow4817 MemRCol4817 10000.000000
R14818 MemRRow4818 MemRCol4818 10000.000000
R14819 MemRRow4819 MemRCol4819 10000.000000
R14820 MemRRow4820 MemRCol4820 10000.000000
R14821 MemRRow4821 MemRCol4821 10000.000000
R14822 MemRRow4822 MemRCol4822 10000.000000
R14823 MemRRow4823 MemRCol4823 10000.000000
R14824 MemRRow4824 MemRCol4824 10000.000000
R14825 MemRRow4825 MemRCol4825 10000.000000
R14826 MemRRow4826 MemRCol4826 10000.000000
R14827 MemRRow4827 MemRCol4827 10000.000000
R14828 MemRRow4828 MemRCol4828 10000.000000
R14829 MemRRow4829 MemRCol4829 10000.000000
R14830 MemRRow4830 MemRCol4830 10000.000000
R14831 MemRRow4831 MemRCol4831 10000.000000
R14832 MemRRow4832 MemRCol4832 10000.000000
R14833 MemRRow4833 MemRCol4833 10000.000000
R14834 MemRRow4834 MemRCol4834 10000.000000
R14835 MemRRow4835 MemRCol4835 10000.000000
R14836 MemRRow4836 MemRCol4836 10000.000000
R14837 MemRRow4837 MemRCol4837 10000.000000
R14838 MemRRow4838 MemRCol4838 10000.000000
R14839 MemRRow4839 MemRCol4839 10000.000000
R14840 MemRRow4840 MemRCol4840 10000.000000
R14841 MemRRow4841 MemRCol4841 10000.000000
R14842 MemRRow4842 MemRCol4842 10000.000000
R14843 MemRRow4843 MemRCol4843 10000.000000
R14844 MemRRow4844 MemRCol4844 10000.000000
R14845 MemRRow4845 MemRCol4845 10000.000000
R14846 MemRRow4846 MemRCol4846 10000.000000
R14847 MemRRow4847 MemRCol4847 10000.000000
R14848 MemRRow4848 MemRCol4848 10000.000000
R14849 MemRRow4849 MemRCol4849 10000.000000
R14850 MemRRow4850 MemRCol4850 10000.000000
R1491 MemRRow491 MemRCol491 10000.000000
R1492 MemRRow492 MemRCol492 10000.000000
R1493 MemRRow493 MemRCol493 10000.000000
R1494 MemRRow494 MemRCol494 10000.000000
R1495 MemRRow495 MemRCol495 10000.000000
R1496 MemRRow496 MemRCol496 10000.000000
R1497 MemRRow497 MemRCol497 10000.000000
R1498 MemRRow498 MemRCol498 10000.000000
R1499 MemRRow499 MemRCol499 10000.000000
R14910 MemRRow4910 MemRCol4910 10000.000000
R14911 MemRRow4911 MemRCol4911 10000.000000
R14912 MemRRow4912 MemRCol4912 10000.000000
R14913 MemRRow4913 MemRCol4913 10000.000000
R14914 MemRRow4914 MemRCol4914 10000.000000
R14915 MemRRow4915 MemRCol4915 10000.000000
R14916 MemRRow4916 MemRCol4916 10000.000000
R14917 MemRRow4917 MemRCol4917 10000.000000
R14918 MemRRow4918 MemRCol4918 10000.000000
R14919 MemRRow4919 MemRCol4919 10000.000000
R14920 MemRRow4920 MemRCol4920 10000.000000
R14921 MemRRow4921 MemRCol4921 10000.000000
R14922 MemRRow4922 MemRCol4922 10000.000000
R14923 MemRRow4923 MemRCol4923 10000.000000
R14924 MemRRow4924 MemRCol4924 10000.000000
R14925 MemRRow4925 MemRCol4925 10000.000000
R14926 MemRRow4926 MemRCol4926 10000.000000
R14927 MemRRow4927 MemRCol4927 10000.000000
R14928 MemRRow4928 MemRCol4928 10000.000000
R14929 MemRRow4929 MemRCol4929 10000.000000
R14930 MemRRow4930 MemRCol4930 10000.000000
R14931 MemRRow4931 MemRCol4931 10000.000000
R14932 MemRRow4932 MemRCol4932 10000.000000
R14933 MemRRow4933 MemRCol4933 10000.000000
R14934 MemRRow4934 MemRCol4934 10000.000000
R14935 MemRRow4935 MemRCol4935 10000.000000
R14936 MemRRow4936 MemRCol4936 10000.000000
R14937 MemRRow4937 MemRCol4937 10000.000000
R14938 MemRRow4938 MemRCol4938 10000.000000
R14939 MemRRow4939 MemRCol4939 10000.000000
R14940 MemRRow4940 MemRCol4940 10000.000000
R14941 MemRRow4941 MemRCol4941 10000.000000
R14942 MemRRow4942 MemRCol4942 10000.000000
R14943 MemRRow4943 MemRCol4943 10000.000000
R14944 MemRRow4944 MemRCol4944 10000.000000
R14945 MemRRow4945 MemRCol4945 10000.000000
R14946 MemRRow4946 MemRCol4946 10000.000000
R14947 MemRRow4947 MemRCol4947 10000.000000
R14948 MemRRow4948 MemRCol4948 10000.000000
R14949 MemRRow4949 MemRCol4949 10000.000000
R14950 MemRRow4950 MemRCol4950 10000.000000
R1501 MemRRow501 MemRCol501 10000.000000
R1502 MemRRow502 MemRCol502 10000.000000
R1503 MemRRow503 MemRCol503 10000.000000
R1504 MemRRow504 MemRCol504 10000.000000
R1505 MemRRow505 MemRCol505 10000.000000
R1506 MemRRow506 MemRCol506 10000.000000
R1507 MemRRow507 MemRCol507 10000.000000
R1508 MemRRow508 MemRCol508 10000.000000
R1509 MemRRow509 MemRCol509 10000.000000
R15010 MemRRow5010 MemRCol5010 10000.000000
R15011 MemRRow5011 MemRCol5011 10000.000000
R15012 MemRRow5012 MemRCol5012 10000.000000
R15013 MemRRow5013 MemRCol5013 10000.000000
R15014 MemRRow5014 MemRCol5014 10000.000000
R15015 MemRRow5015 MemRCol5015 10000.000000
R15016 MemRRow5016 MemRCol5016 10000.000000
R15017 MemRRow5017 MemRCol5017 10000.000000
R15018 MemRRow5018 MemRCol5018 10000.000000
R15019 MemRRow5019 MemRCol5019 10000.000000
R15020 MemRRow5020 MemRCol5020 10000.000000
R15021 MemRRow5021 MemRCol5021 10000.000000
R15022 MemRRow5022 MemRCol5022 10000.000000
R15023 MemRRow5023 MemRCol5023 10000.000000
R15024 MemRRow5024 MemRCol5024 10000.000000
R15025 MemRRow5025 MemRCol5025 10000.000000
R15026 MemRRow5026 MemRCol5026 10000.000000
R15027 MemRRow5027 MemRCol5027 10000.000000
R15028 MemRRow5028 MemRCol5028 10000.000000
R15029 MemRRow5029 MemRCol5029 10000.000000
R15030 MemRRow5030 MemRCol5030 10000.000000
R15031 MemRRow5031 MemRCol5031 10000.000000
R15032 MemRRow5032 MemRCol5032 10000.000000
R15033 MemRRow5033 MemRCol5033 10000.000000
R15034 MemRRow5034 MemRCol5034 10000.000000
R15035 MemRRow5035 MemRCol5035 10000.000000
R15036 MemRRow5036 MemRCol5036 10000.000000
R15037 MemRRow5037 MemRCol5037 10000.000000
R15038 MemRRow5038 MemRCol5038 10000.000000
R15039 MemRRow5039 MemRCol5039 10000.000000
R15040 MemRRow5040 MemRCol5040 10000.000000
R15041 MemRRow5041 MemRCol5041 10000.000000
R15042 MemRRow5042 MemRCol5042 10000.000000
R15043 MemRRow5043 MemRCol5043 10000.000000
R15044 MemRRow5044 MemRCol5044 10000.000000
R15045 MemRRow5045 MemRCol5045 10000.000000
R15046 MemRRow5046 MemRCol5046 10000.000000
R15047 MemRRow5047 MemRCol5047 10000.000000
R15048 MemRRow5048 MemRCol5048 10000.000000
R15049 MemRRow5049 MemRCol5049 10000.000000
R15050 MemRRow5050 MemRCol5050 10000.000000

*Line Row Resistances
R211 MemRRow11 MemRRow12 1000.000000
R212 MemRRow12 MemRRow13 1000.000000
R213 MemRRow13 MemRRow14 1000.000000
R214 MemRRow14 MemRRow15 1000.000000
R215 MemRRow15 MemRRow16 1000.000000
R216 MemRRow16 MemRRow17 1000.000000
R217 MemRRow17 MemRRow18 1000.000000
R218 MemRRow18 MemRRow19 1000.000000
R219 MemRRow19 MemRRow110 1000.000000
R2110 MemRRow110 MemRRow111 1000.000000
R2111 MemRRow111 MemRRow112 1000.000000
R2112 MemRRow112 MemRRow113 1000.000000
R2113 MemRRow113 MemRRow114 1000.000000
R2114 MemRRow114 MemRRow115 1000.000000
R2115 MemRRow115 MemRRow116 1000.000000
R2116 MemRRow116 MemRRow117 1000.000000
R2117 MemRRow117 MemRRow118 1000.000000
R2118 MemRRow118 MemRRow119 1000.000000
R2119 MemRRow119 MemRRow120 1000.000000
R2120 MemRRow120 MemRRow121 1000.000000
R2121 MemRRow121 MemRRow122 1000.000000
R2122 MemRRow122 MemRRow123 1000.000000
R2123 MemRRow123 MemRRow124 1000.000000
R2124 MemRRow124 MemRRow125 1000.000000
R2125 MemRRow125 MemRRow126 1000.000000
R2126 MemRRow126 MemRRow127 1000.000000
R2127 MemRRow127 MemRRow128 1000.000000
R2128 MemRRow128 MemRRow129 1000.000000
R2129 MemRRow129 MemRRow130 1000.000000
R2130 MemRRow130 MemRRow131 1000.000000
R2131 MemRRow131 MemRRow132 1000.000000
R2132 MemRRow132 MemRRow133 1000.000000
R2133 MemRRow133 MemRRow134 1000.000000
R2134 MemRRow134 MemRRow135 1000.000000
R2135 MemRRow135 MemRRow136 1000.000000
R2136 MemRRow136 MemRRow137 1000.000000
R2137 MemRRow137 MemRRow138 1000.000000
R2138 MemRRow138 MemRRow139 1000.000000
R2139 MemRRow139 MemRRow140 1000.000000
R2140 MemRRow140 MemRRow141 1000.000000
R2141 MemRRow141 MemRRow142 1000.000000
R2142 MemRRow142 MemRRow143 1000.000000
R2143 MemRRow143 MemRRow144 1000.000000
R2144 MemRRow144 MemRRow145 1000.000000
R2145 MemRRow145 MemRRow146 1000.000000
R2146 MemRRow146 MemRRow147 1000.000000
R2147 MemRRow147 MemRRow148 1000.000000
R2148 MemRRow148 MemRRow149 1000.000000
R2149 MemRRow149 MemRRow150 1000.000000
R2150 MemRRow150 MemRRow151 1000.000000
R221 MemRRow21 MemRRow22 1000.000000
R222 MemRRow22 MemRRow23 1000.000000
R223 MemRRow23 MemRRow24 1000.000000
R224 MemRRow24 MemRRow25 1000.000000
R225 MemRRow25 MemRRow26 1000.000000
R226 MemRRow26 MemRRow27 1000.000000
R227 MemRRow27 MemRRow28 1000.000000
R228 MemRRow28 MemRRow29 1000.000000
R229 MemRRow29 MemRRow210 1000.000000
R2210 MemRRow210 MemRRow211 1000.000000
R2211 MemRRow211 MemRRow212 1000.000000
R2212 MemRRow212 MemRRow213 1000.000000
R2213 MemRRow213 MemRRow214 1000.000000
R2214 MemRRow214 MemRRow215 1000.000000
R2215 MemRRow215 MemRRow216 1000.000000
R2216 MemRRow216 MemRRow217 1000.000000
R2217 MemRRow217 MemRRow218 1000.000000
R2218 MemRRow218 MemRRow219 1000.000000
R2219 MemRRow219 MemRRow220 1000.000000
R2220 MemRRow220 MemRRow221 1000.000000
R2221 MemRRow221 MemRRow222 1000.000000
R2222 MemRRow222 MemRRow223 1000.000000
R2223 MemRRow223 MemRRow224 1000.000000
R2224 MemRRow224 MemRRow225 1000.000000
R2225 MemRRow225 MemRRow226 1000.000000
R2226 MemRRow226 MemRRow227 1000.000000
R2227 MemRRow227 MemRRow228 1000.000000
R2228 MemRRow228 MemRRow229 1000.000000
R2229 MemRRow229 MemRRow230 1000.000000
R2230 MemRRow230 MemRRow231 1000.000000
R2231 MemRRow231 MemRRow232 1000.000000
R2232 MemRRow232 MemRRow233 1000.000000
R2233 MemRRow233 MemRRow234 1000.000000
R2234 MemRRow234 MemRRow235 1000.000000
R2235 MemRRow235 MemRRow236 1000.000000
R2236 MemRRow236 MemRRow237 1000.000000
R2237 MemRRow237 MemRRow238 1000.000000
R2238 MemRRow238 MemRRow239 1000.000000
R2239 MemRRow239 MemRRow240 1000.000000
R2240 MemRRow240 MemRRow241 1000.000000
R2241 MemRRow241 MemRRow242 1000.000000
R2242 MemRRow242 MemRRow243 1000.000000
R2243 MemRRow243 MemRRow244 1000.000000
R2244 MemRRow244 MemRRow245 1000.000000
R2245 MemRRow245 MemRRow246 1000.000000
R2246 MemRRow246 MemRRow247 1000.000000
R2247 MemRRow247 MemRRow248 1000.000000
R2248 MemRRow248 MemRRow249 1000.000000
R2249 MemRRow249 MemRRow250 1000.000000
R2250 MemRRow250 MemRRow251 1000.000000
R231 MemRRow31 MemRRow32 1000.000000
R232 MemRRow32 MemRRow33 1000.000000
R233 MemRRow33 MemRRow34 1000.000000
R234 MemRRow34 MemRRow35 1000.000000
R235 MemRRow35 MemRRow36 1000.000000
R236 MemRRow36 MemRRow37 1000.000000
R237 MemRRow37 MemRRow38 1000.000000
R238 MemRRow38 MemRRow39 1000.000000
R239 MemRRow39 MemRRow310 1000.000000
R2310 MemRRow310 MemRRow311 1000.000000
R2311 MemRRow311 MemRRow312 1000.000000
R2312 MemRRow312 MemRRow313 1000.000000
R2313 MemRRow313 MemRRow314 1000.000000
R2314 MemRRow314 MemRRow315 1000.000000
R2315 MemRRow315 MemRRow316 1000.000000
R2316 MemRRow316 MemRRow317 1000.000000
R2317 MemRRow317 MemRRow318 1000.000000
R2318 MemRRow318 MemRRow319 1000.000000
R2319 MemRRow319 MemRRow320 1000.000000
R2320 MemRRow320 MemRRow321 1000.000000
R2321 MemRRow321 MemRRow322 1000.000000
R2322 MemRRow322 MemRRow323 1000.000000
R2323 MemRRow323 MemRRow324 1000.000000
R2324 MemRRow324 MemRRow325 1000.000000
R2325 MemRRow325 MemRRow326 1000.000000
R2326 MemRRow326 MemRRow327 1000.000000
R2327 MemRRow327 MemRRow328 1000.000000
R2328 MemRRow328 MemRRow329 1000.000000
R2329 MemRRow329 MemRRow330 1000.000000
R2330 MemRRow330 MemRRow331 1000.000000
R2331 MemRRow331 MemRRow332 1000.000000
R2332 MemRRow332 MemRRow333 1000.000000
R2333 MemRRow333 MemRRow334 1000.000000
R2334 MemRRow334 MemRRow335 1000.000000
R2335 MemRRow335 MemRRow336 1000.000000
R2336 MemRRow336 MemRRow337 1000.000000
R2337 MemRRow337 MemRRow338 1000.000000
R2338 MemRRow338 MemRRow339 1000.000000
R2339 MemRRow339 MemRRow340 1000.000000
R2340 MemRRow340 MemRRow341 1000.000000
R2341 MemRRow341 MemRRow342 1000.000000
R2342 MemRRow342 MemRRow343 1000.000000
R2343 MemRRow343 MemRRow344 1000.000000
R2344 MemRRow344 MemRRow345 1000.000000
R2345 MemRRow345 MemRRow346 1000.000000
R2346 MemRRow346 MemRRow347 1000.000000
R2347 MemRRow347 MemRRow348 1000.000000
R2348 MemRRow348 MemRRow349 1000.000000
R2349 MemRRow349 MemRRow350 1000.000000
R2350 MemRRow350 MemRRow351 1000.000000
R241 MemRRow41 MemRRow42 1000.000000
R242 MemRRow42 MemRRow43 1000.000000
R243 MemRRow43 MemRRow44 1000.000000
R244 MemRRow44 MemRRow45 1000.000000
R245 MemRRow45 MemRRow46 1000.000000
R246 MemRRow46 MemRRow47 1000.000000
R247 MemRRow47 MemRRow48 1000.000000
R248 MemRRow48 MemRRow49 1000.000000
R249 MemRRow49 MemRRow410 1000.000000
R2410 MemRRow410 MemRRow411 1000.000000
R2411 MemRRow411 MemRRow412 1000.000000
R2412 MemRRow412 MemRRow413 1000.000000
R2413 MemRRow413 MemRRow414 1000.000000
R2414 MemRRow414 MemRRow415 1000.000000
R2415 MemRRow415 MemRRow416 1000.000000
R2416 MemRRow416 MemRRow417 1000.000000
R2417 MemRRow417 MemRRow418 1000.000000
R2418 MemRRow418 MemRRow419 1000.000000
R2419 MemRRow419 MemRRow420 1000.000000
R2420 MemRRow420 MemRRow421 1000.000000
R2421 MemRRow421 MemRRow422 1000.000000
R2422 MemRRow422 MemRRow423 1000.000000
R2423 MemRRow423 MemRRow424 1000.000000
R2424 MemRRow424 MemRRow425 1000.000000
R2425 MemRRow425 MemRRow426 1000.000000
R2426 MemRRow426 MemRRow427 1000.000000
R2427 MemRRow427 MemRRow428 1000.000000
R2428 MemRRow428 MemRRow429 1000.000000
R2429 MemRRow429 MemRRow430 1000.000000
R2430 MemRRow430 MemRRow431 1000.000000
R2431 MemRRow431 MemRRow432 1000.000000
R2432 MemRRow432 MemRRow433 1000.000000
R2433 MemRRow433 MemRRow434 1000.000000
R2434 MemRRow434 MemRRow435 1000.000000
R2435 MemRRow435 MemRRow436 1000.000000
R2436 MemRRow436 MemRRow437 1000.000000
R2437 MemRRow437 MemRRow438 1000.000000
R2438 MemRRow438 MemRRow439 1000.000000
R2439 MemRRow439 MemRRow440 1000.000000
R2440 MemRRow440 MemRRow441 1000.000000
R2441 MemRRow441 MemRRow442 1000.000000
R2442 MemRRow442 MemRRow443 1000.000000
R2443 MemRRow443 MemRRow444 1000.000000
R2444 MemRRow444 MemRRow445 1000.000000
R2445 MemRRow445 MemRRow446 1000.000000
R2446 MemRRow446 MemRRow447 1000.000000
R2447 MemRRow447 MemRRow448 1000.000000
R2448 MemRRow448 MemRRow449 1000.000000
R2449 MemRRow449 MemRRow450 1000.000000
R2450 MemRRow450 MemRRow451 1000.000000
R251 MemRRow51 MemRRow52 1000.000000
R252 MemRRow52 MemRRow53 1000.000000
R253 MemRRow53 MemRRow54 1000.000000
R254 MemRRow54 MemRRow55 1000.000000
R255 MemRRow55 MemRRow56 1000.000000
R256 MemRRow56 MemRRow57 1000.000000
R257 MemRRow57 MemRRow58 1000.000000
R258 MemRRow58 MemRRow59 1000.000000
R259 MemRRow59 MemRRow510 1000.000000
R2510 MemRRow510 MemRRow511 1000.000000
R2511 MemRRow511 MemRRow512 1000.000000
R2512 MemRRow512 MemRRow513 1000.000000
R2513 MemRRow513 MemRRow514 1000.000000
R2514 MemRRow514 MemRRow515 1000.000000
R2515 MemRRow515 MemRRow516 1000.000000
R2516 MemRRow516 MemRRow517 1000.000000
R2517 MemRRow517 MemRRow518 1000.000000
R2518 MemRRow518 MemRRow519 1000.000000
R2519 MemRRow519 MemRRow520 1000.000000
R2520 MemRRow520 MemRRow521 1000.000000
R2521 MemRRow521 MemRRow522 1000.000000
R2522 MemRRow522 MemRRow523 1000.000000
R2523 MemRRow523 MemRRow524 1000.000000
R2524 MemRRow524 MemRRow525 1000.000000
R2525 MemRRow525 MemRRow526 1000.000000
R2526 MemRRow526 MemRRow527 1000.000000
R2527 MemRRow527 MemRRow528 1000.000000
R2528 MemRRow528 MemRRow529 1000.000000
R2529 MemRRow529 MemRRow530 1000.000000
R2530 MemRRow530 MemRRow531 1000.000000
R2531 MemRRow531 MemRRow532 1000.000000
R2532 MemRRow532 MemRRow533 1000.000000
R2533 MemRRow533 MemRRow534 1000.000000
R2534 MemRRow534 MemRRow535 1000.000000
R2535 MemRRow535 MemRRow536 1000.000000
R2536 MemRRow536 MemRRow537 1000.000000
R2537 MemRRow537 MemRRow538 1000.000000
R2538 MemRRow538 MemRRow539 1000.000000
R2539 MemRRow539 MemRRow540 1000.000000
R2540 MemRRow540 MemRRow541 1000.000000
R2541 MemRRow541 MemRRow542 1000.000000
R2542 MemRRow542 MemRRow543 1000.000000
R2543 MemRRow543 MemRRow544 1000.000000
R2544 MemRRow544 MemRRow545 1000.000000
R2545 MemRRow545 MemRRow546 1000.000000
R2546 MemRRow546 MemRRow547 1000.000000
R2547 MemRRow547 MemRRow548 1000.000000
R2548 MemRRow548 MemRRow549 1000.000000
R2549 MemRRow549 MemRRow550 1000.000000
R2550 MemRRow550 MemRRow551 1000.000000
R261 MemRRow61 MemRRow62 1000.000000
R262 MemRRow62 MemRRow63 1000.000000
R263 MemRRow63 MemRRow64 1000.000000
R264 MemRRow64 MemRRow65 1000.000000
R265 MemRRow65 MemRRow66 1000.000000
R266 MemRRow66 MemRRow67 1000.000000
R267 MemRRow67 MemRRow68 1000.000000
R268 MemRRow68 MemRRow69 1000.000000
R269 MemRRow69 MemRRow610 1000.000000
R2610 MemRRow610 MemRRow611 1000.000000
R2611 MemRRow611 MemRRow612 1000.000000
R2612 MemRRow612 MemRRow613 1000.000000
R2613 MemRRow613 MemRRow614 1000.000000
R2614 MemRRow614 MemRRow615 1000.000000
R2615 MemRRow615 MemRRow616 1000.000000
R2616 MemRRow616 MemRRow617 1000.000000
R2617 MemRRow617 MemRRow618 1000.000000
R2618 MemRRow618 MemRRow619 1000.000000
R2619 MemRRow619 MemRRow620 1000.000000
R2620 MemRRow620 MemRRow621 1000.000000
R2621 MemRRow621 MemRRow622 1000.000000
R2622 MemRRow622 MemRRow623 1000.000000
R2623 MemRRow623 MemRRow624 1000.000000
R2624 MemRRow624 MemRRow625 1000.000000
R2625 MemRRow625 MemRRow626 1000.000000
R2626 MemRRow626 MemRRow627 1000.000000
R2627 MemRRow627 MemRRow628 1000.000000
R2628 MemRRow628 MemRRow629 1000.000000
R2629 MemRRow629 MemRRow630 1000.000000
R2630 MemRRow630 MemRRow631 1000.000000
R2631 MemRRow631 MemRRow632 1000.000000
R2632 MemRRow632 MemRRow633 1000.000000
R2633 MemRRow633 MemRRow634 1000.000000
R2634 MemRRow634 MemRRow635 1000.000000
R2635 MemRRow635 MemRRow636 1000.000000
R2636 MemRRow636 MemRRow637 1000.000000
R2637 MemRRow637 MemRRow638 1000.000000
R2638 MemRRow638 MemRRow639 1000.000000
R2639 MemRRow639 MemRRow640 1000.000000
R2640 MemRRow640 MemRRow641 1000.000000
R2641 MemRRow641 MemRRow642 1000.000000
R2642 MemRRow642 MemRRow643 1000.000000
R2643 MemRRow643 MemRRow644 1000.000000
R2644 MemRRow644 MemRRow645 1000.000000
R2645 MemRRow645 MemRRow646 1000.000000
R2646 MemRRow646 MemRRow647 1000.000000
R2647 MemRRow647 MemRRow648 1000.000000
R2648 MemRRow648 MemRRow649 1000.000000
R2649 MemRRow649 MemRRow650 1000.000000
R2650 MemRRow650 MemRRow651 1000.000000
R271 MemRRow71 MemRRow72 1000.000000
R272 MemRRow72 MemRRow73 1000.000000
R273 MemRRow73 MemRRow74 1000.000000
R274 MemRRow74 MemRRow75 1000.000000
R275 MemRRow75 MemRRow76 1000.000000
R276 MemRRow76 MemRRow77 1000.000000
R277 MemRRow77 MemRRow78 1000.000000
R278 MemRRow78 MemRRow79 1000.000000
R279 MemRRow79 MemRRow710 1000.000000
R2710 MemRRow710 MemRRow711 1000.000000
R2711 MemRRow711 MemRRow712 1000.000000
R2712 MemRRow712 MemRRow713 1000.000000
R2713 MemRRow713 MemRRow714 1000.000000
R2714 MemRRow714 MemRRow715 1000.000000
R2715 MemRRow715 MemRRow716 1000.000000
R2716 MemRRow716 MemRRow717 1000.000000
R2717 MemRRow717 MemRRow718 1000.000000
R2718 MemRRow718 MemRRow719 1000.000000
R2719 MemRRow719 MemRRow720 1000.000000
R2720 MemRRow720 MemRRow721 1000.000000
R2721 MemRRow721 MemRRow722 1000.000000
R2722 MemRRow722 MemRRow723 1000.000000
R2723 MemRRow723 MemRRow724 1000.000000
R2724 MemRRow724 MemRRow725 1000.000000
R2725 MemRRow725 MemRRow726 1000.000000
R2726 MemRRow726 MemRRow727 1000.000000
R2727 MemRRow727 MemRRow728 1000.000000
R2728 MemRRow728 MemRRow729 1000.000000
R2729 MemRRow729 MemRRow730 1000.000000
R2730 MemRRow730 MemRRow731 1000.000000
R2731 MemRRow731 MemRRow732 1000.000000
R2732 MemRRow732 MemRRow733 1000.000000
R2733 MemRRow733 MemRRow734 1000.000000
R2734 MemRRow734 MemRRow735 1000.000000
R2735 MemRRow735 MemRRow736 1000.000000
R2736 MemRRow736 MemRRow737 1000.000000
R2737 MemRRow737 MemRRow738 1000.000000
R2738 MemRRow738 MemRRow739 1000.000000
R2739 MemRRow739 MemRRow740 1000.000000
R2740 MemRRow740 MemRRow741 1000.000000
R2741 MemRRow741 MemRRow742 1000.000000
R2742 MemRRow742 MemRRow743 1000.000000
R2743 MemRRow743 MemRRow744 1000.000000
R2744 MemRRow744 MemRRow745 1000.000000
R2745 MemRRow745 MemRRow746 1000.000000
R2746 MemRRow746 MemRRow747 1000.000000
R2747 MemRRow747 MemRRow748 1000.000000
R2748 MemRRow748 MemRRow749 1000.000000
R2749 MemRRow749 MemRRow750 1000.000000
R2750 MemRRow750 MemRRow751 1000.000000
R281 MemRRow81 MemRRow82 1000.000000
R282 MemRRow82 MemRRow83 1000.000000
R283 MemRRow83 MemRRow84 1000.000000
R284 MemRRow84 MemRRow85 1000.000000
R285 MemRRow85 MemRRow86 1000.000000
R286 MemRRow86 MemRRow87 1000.000000
R287 MemRRow87 MemRRow88 1000.000000
R288 MemRRow88 MemRRow89 1000.000000
R289 MemRRow89 MemRRow810 1000.000000
R2810 MemRRow810 MemRRow811 1000.000000
R2811 MemRRow811 MemRRow812 1000.000000
R2812 MemRRow812 MemRRow813 1000.000000
R2813 MemRRow813 MemRRow814 1000.000000
R2814 MemRRow814 MemRRow815 1000.000000
R2815 MemRRow815 MemRRow816 1000.000000
R2816 MemRRow816 MemRRow817 1000.000000
R2817 MemRRow817 MemRRow818 1000.000000
R2818 MemRRow818 MemRRow819 1000.000000
R2819 MemRRow819 MemRRow820 1000.000000
R2820 MemRRow820 MemRRow821 1000.000000
R2821 MemRRow821 MemRRow822 1000.000000
R2822 MemRRow822 MemRRow823 1000.000000
R2823 MemRRow823 MemRRow824 1000.000000
R2824 MemRRow824 MemRRow825 1000.000000
R2825 MemRRow825 MemRRow826 1000.000000
R2826 MemRRow826 MemRRow827 1000.000000
R2827 MemRRow827 MemRRow828 1000.000000
R2828 MemRRow828 MemRRow829 1000.000000
R2829 MemRRow829 MemRRow830 1000.000000
R2830 MemRRow830 MemRRow831 1000.000000
R2831 MemRRow831 MemRRow832 1000.000000
R2832 MemRRow832 MemRRow833 1000.000000
R2833 MemRRow833 MemRRow834 1000.000000
R2834 MemRRow834 MemRRow835 1000.000000
R2835 MemRRow835 MemRRow836 1000.000000
R2836 MemRRow836 MemRRow837 1000.000000
R2837 MemRRow837 MemRRow838 1000.000000
R2838 MemRRow838 MemRRow839 1000.000000
R2839 MemRRow839 MemRRow840 1000.000000
R2840 MemRRow840 MemRRow841 1000.000000
R2841 MemRRow841 MemRRow842 1000.000000
R2842 MemRRow842 MemRRow843 1000.000000
R2843 MemRRow843 MemRRow844 1000.000000
R2844 MemRRow844 MemRRow845 1000.000000
R2845 MemRRow845 MemRRow846 1000.000000
R2846 MemRRow846 MemRRow847 1000.000000
R2847 MemRRow847 MemRRow848 1000.000000
R2848 MemRRow848 MemRRow849 1000.000000
R2849 MemRRow849 MemRRow850 1000.000000
R2850 MemRRow850 MemRRow851 1000.000000
R291 MemRRow91 MemRRow92 1000.000000
R292 MemRRow92 MemRRow93 1000.000000
R293 MemRRow93 MemRRow94 1000.000000
R294 MemRRow94 MemRRow95 1000.000000
R295 MemRRow95 MemRRow96 1000.000000
R296 MemRRow96 MemRRow97 1000.000000
R297 MemRRow97 MemRRow98 1000.000000
R298 MemRRow98 MemRRow99 1000.000000
R299 MemRRow99 MemRRow910 1000.000000
R2910 MemRRow910 MemRRow911 1000.000000
R2911 MemRRow911 MemRRow912 1000.000000
R2912 MemRRow912 MemRRow913 1000.000000
R2913 MemRRow913 MemRRow914 1000.000000
R2914 MemRRow914 MemRRow915 1000.000000
R2915 MemRRow915 MemRRow916 1000.000000
R2916 MemRRow916 MemRRow917 1000.000000
R2917 MemRRow917 MemRRow918 1000.000000
R2918 MemRRow918 MemRRow919 1000.000000
R2919 MemRRow919 MemRRow920 1000.000000
R2920 MemRRow920 MemRRow921 1000.000000
R2921 MemRRow921 MemRRow922 1000.000000
R2922 MemRRow922 MemRRow923 1000.000000
R2923 MemRRow923 MemRRow924 1000.000000
R2924 MemRRow924 MemRRow925 1000.000000
R2925 MemRRow925 MemRRow926 1000.000000
R2926 MemRRow926 MemRRow927 1000.000000
R2927 MemRRow927 MemRRow928 1000.000000
R2928 MemRRow928 MemRRow929 1000.000000
R2929 MemRRow929 MemRRow930 1000.000000
R2930 MemRRow930 MemRRow931 1000.000000
R2931 MemRRow931 MemRRow932 1000.000000
R2932 MemRRow932 MemRRow933 1000.000000
R2933 MemRRow933 MemRRow934 1000.000000
R2934 MemRRow934 MemRRow935 1000.000000
R2935 MemRRow935 MemRRow936 1000.000000
R2936 MemRRow936 MemRRow937 1000.000000
R2937 MemRRow937 MemRRow938 1000.000000
R2938 MemRRow938 MemRRow939 1000.000000
R2939 MemRRow939 MemRRow940 1000.000000
R2940 MemRRow940 MemRRow941 1000.000000
R2941 MemRRow941 MemRRow942 1000.000000
R2942 MemRRow942 MemRRow943 1000.000000
R2943 MemRRow943 MemRRow944 1000.000000
R2944 MemRRow944 MemRRow945 1000.000000
R2945 MemRRow945 MemRRow946 1000.000000
R2946 MemRRow946 MemRRow947 1000.000000
R2947 MemRRow947 MemRRow948 1000.000000
R2948 MemRRow948 MemRRow949 1000.000000
R2949 MemRRow949 MemRRow950 1000.000000
R2950 MemRRow950 MemRRow951 1000.000000
R2101 MemRRow101 MemRRow102 1000.000000
R2102 MemRRow102 MemRRow103 1000.000000
R2103 MemRRow103 MemRRow104 1000.000000
R2104 MemRRow104 MemRRow105 1000.000000
R2105 MemRRow105 MemRRow106 1000.000000
R2106 MemRRow106 MemRRow107 1000.000000
R2107 MemRRow107 MemRRow108 1000.000000
R2108 MemRRow108 MemRRow109 1000.000000
R2109 MemRRow109 MemRRow1010 1000.000000
R21010 MemRRow1010 MemRRow1011 1000.000000
R21011 MemRRow1011 MemRRow1012 1000.000000
R21012 MemRRow1012 MemRRow1013 1000.000000
R21013 MemRRow1013 MemRRow1014 1000.000000
R21014 MemRRow1014 MemRRow1015 1000.000000
R21015 MemRRow1015 MemRRow1016 1000.000000
R21016 MemRRow1016 MemRRow1017 1000.000000
R21017 MemRRow1017 MemRRow1018 1000.000000
R21018 MemRRow1018 MemRRow1019 1000.000000
R21019 MemRRow1019 MemRRow1020 1000.000000
R21020 MemRRow1020 MemRRow1021 1000.000000
R21021 MemRRow1021 MemRRow1022 1000.000000
R21022 MemRRow1022 MemRRow1023 1000.000000
R21023 MemRRow1023 MemRRow1024 1000.000000
R21024 MemRRow1024 MemRRow1025 1000.000000
R21025 MemRRow1025 MemRRow1026 1000.000000
R21026 MemRRow1026 MemRRow1027 1000.000000
R21027 MemRRow1027 MemRRow1028 1000.000000
R21028 MemRRow1028 MemRRow1029 1000.000000
R21029 MemRRow1029 MemRRow1030 1000.000000
R21030 MemRRow1030 MemRRow1031 1000.000000
R21031 MemRRow1031 MemRRow1032 1000.000000
R21032 MemRRow1032 MemRRow1033 1000.000000
R21033 MemRRow1033 MemRRow1034 1000.000000
R21034 MemRRow1034 MemRRow1035 1000.000000
R21035 MemRRow1035 MemRRow1036 1000.000000
R21036 MemRRow1036 MemRRow1037 1000.000000
R21037 MemRRow1037 MemRRow1038 1000.000000
R21038 MemRRow1038 MemRRow1039 1000.000000
R21039 MemRRow1039 MemRRow1040 1000.000000
R21040 MemRRow1040 MemRRow1041 1000.000000
R21041 MemRRow1041 MemRRow1042 1000.000000
R21042 MemRRow1042 MemRRow1043 1000.000000
R21043 MemRRow1043 MemRRow1044 1000.000000
R21044 MemRRow1044 MemRRow1045 1000.000000
R21045 MemRRow1045 MemRRow1046 1000.000000
R21046 MemRRow1046 MemRRow1047 1000.000000
R21047 MemRRow1047 MemRRow1048 1000.000000
R21048 MemRRow1048 MemRRow1049 1000.000000
R21049 MemRRow1049 MemRRow1050 1000.000000
R21050 MemRRow1050 MemRRow1051 1000.000000
R2111 MemRRow111 MemRRow112 1000.000000
R2112 MemRRow112 MemRRow113 1000.000000
R2113 MemRRow113 MemRRow114 1000.000000
R2114 MemRRow114 MemRRow115 1000.000000
R2115 MemRRow115 MemRRow116 1000.000000
R2116 MemRRow116 MemRRow117 1000.000000
R2117 MemRRow117 MemRRow118 1000.000000
R2118 MemRRow118 MemRRow119 1000.000000
R2119 MemRRow119 MemRRow1110 1000.000000
R21110 MemRRow1110 MemRRow1111 1000.000000
R21111 MemRRow1111 MemRRow1112 1000.000000
R21112 MemRRow1112 MemRRow1113 1000.000000
R21113 MemRRow1113 MemRRow1114 1000.000000
R21114 MemRRow1114 MemRRow1115 1000.000000
R21115 MemRRow1115 MemRRow1116 1000.000000
R21116 MemRRow1116 MemRRow1117 1000.000000
R21117 MemRRow1117 MemRRow1118 1000.000000
R21118 MemRRow1118 MemRRow1119 1000.000000
R21119 MemRRow1119 MemRRow1120 1000.000000
R21120 MemRRow1120 MemRRow1121 1000.000000
R21121 MemRRow1121 MemRRow1122 1000.000000
R21122 MemRRow1122 MemRRow1123 1000.000000
R21123 MemRRow1123 MemRRow1124 1000.000000
R21124 MemRRow1124 MemRRow1125 1000.000000
R21125 MemRRow1125 MemRRow1126 1000.000000
R21126 MemRRow1126 MemRRow1127 1000.000000
R21127 MemRRow1127 MemRRow1128 1000.000000
R21128 MemRRow1128 MemRRow1129 1000.000000
R21129 MemRRow1129 MemRRow1130 1000.000000
R21130 MemRRow1130 MemRRow1131 1000.000000
R21131 MemRRow1131 MemRRow1132 1000.000000
R21132 MemRRow1132 MemRRow1133 1000.000000
R21133 MemRRow1133 MemRRow1134 1000.000000
R21134 MemRRow1134 MemRRow1135 1000.000000
R21135 MemRRow1135 MemRRow1136 1000.000000
R21136 MemRRow1136 MemRRow1137 1000.000000
R21137 MemRRow1137 MemRRow1138 1000.000000
R21138 MemRRow1138 MemRRow1139 1000.000000
R21139 MemRRow1139 MemRRow1140 1000.000000
R21140 MemRRow1140 MemRRow1141 1000.000000
R21141 MemRRow1141 MemRRow1142 1000.000000
R21142 MemRRow1142 MemRRow1143 1000.000000
R21143 MemRRow1143 MemRRow1144 1000.000000
R21144 MemRRow1144 MemRRow1145 1000.000000
R21145 MemRRow1145 MemRRow1146 1000.000000
R21146 MemRRow1146 MemRRow1147 1000.000000
R21147 MemRRow1147 MemRRow1148 1000.000000
R21148 MemRRow1148 MemRRow1149 1000.000000
R21149 MemRRow1149 MemRRow1150 1000.000000
R21150 MemRRow1150 MemRRow1151 1000.000000
R2121 MemRRow121 MemRRow122 1000.000000
R2122 MemRRow122 MemRRow123 1000.000000
R2123 MemRRow123 MemRRow124 1000.000000
R2124 MemRRow124 MemRRow125 1000.000000
R2125 MemRRow125 MemRRow126 1000.000000
R2126 MemRRow126 MemRRow127 1000.000000
R2127 MemRRow127 MemRRow128 1000.000000
R2128 MemRRow128 MemRRow129 1000.000000
R2129 MemRRow129 MemRRow1210 1000.000000
R21210 MemRRow1210 MemRRow1211 1000.000000
R21211 MemRRow1211 MemRRow1212 1000.000000
R21212 MemRRow1212 MemRRow1213 1000.000000
R21213 MemRRow1213 MemRRow1214 1000.000000
R21214 MemRRow1214 MemRRow1215 1000.000000
R21215 MemRRow1215 MemRRow1216 1000.000000
R21216 MemRRow1216 MemRRow1217 1000.000000
R21217 MemRRow1217 MemRRow1218 1000.000000
R21218 MemRRow1218 MemRRow1219 1000.000000
R21219 MemRRow1219 MemRRow1220 1000.000000
R21220 MemRRow1220 MemRRow1221 1000.000000
R21221 MemRRow1221 MemRRow1222 1000.000000
R21222 MemRRow1222 MemRRow1223 1000.000000
R21223 MemRRow1223 MemRRow1224 1000.000000
R21224 MemRRow1224 MemRRow1225 1000.000000
R21225 MemRRow1225 MemRRow1226 1000.000000
R21226 MemRRow1226 MemRRow1227 1000.000000
R21227 MemRRow1227 MemRRow1228 1000.000000
R21228 MemRRow1228 MemRRow1229 1000.000000
R21229 MemRRow1229 MemRRow1230 1000.000000
R21230 MemRRow1230 MemRRow1231 1000.000000
R21231 MemRRow1231 MemRRow1232 1000.000000
R21232 MemRRow1232 MemRRow1233 1000.000000
R21233 MemRRow1233 MemRRow1234 1000.000000
R21234 MemRRow1234 MemRRow1235 1000.000000
R21235 MemRRow1235 MemRRow1236 1000.000000
R21236 MemRRow1236 MemRRow1237 1000.000000
R21237 MemRRow1237 MemRRow1238 1000.000000
R21238 MemRRow1238 MemRRow1239 1000.000000
R21239 MemRRow1239 MemRRow1240 1000.000000
R21240 MemRRow1240 MemRRow1241 1000.000000
R21241 MemRRow1241 MemRRow1242 1000.000000
R21242 MemRRow1242 MemRRow1243 1000.000000
R21243 MemRRow1243 MemRRow1244 1000.000000
R21244 MemRRow1244 MemRRow1245 1000.000000
R21245 MemRRow1245 MemRRow1246 1000.000000
R21246 MemRRow1246 MemRRow1247 1000.000000
R21247 MemRRow1247 MemRRow1248 1000.000000
R21248 MemRRow1248 MemRRow1249 1000.000000
R21249 MemRRow1249 MemRRow1250 1000.000000
R21250 MemRRow1250 MemRRow1251 1000.000000
R2131 MemRRow131 MemRRow132 1000.000000
R2132 MemRRow132 MemRRow133 1000.000000
R2133 MemRRow133 MemRRow134 1000.000000
R2134 MemRRow134 MemRRow135 1000.000000
R2135 MemRRow135 MemRRow136 1000.000000
R2136 MemRRow136 MemRRow137 1000.000000
R2137 MemRRow137 MemRRow138 1000.000000
R2138 MemRRow138 MemRRow139 1000.000000
R2139 MemRRow139 MemRRow1310 1000.000000
R21310 MemRRow1310 MemRRow1311 1000.000000
R21311 MemRRow1311 MemRRow1312 1000.000000
R21312 MemRRow1312 MemRRow1313 1000.000000
R21313 MemRRow1313 MemRRow1314 1000.000000
R21314 MemRRow1314 MemRRow1315 1000.000000
R21315 MemRRow1315 MemRRow1316 1000.000000
R21316 MemRRow1316 MemRRow1317 1000.000000
R21317 MemRRow1317 MemRRow1318 1000.000000
R21318 MemRRow1318 MemRRow1319 1000.000000
R21319 MemRRow1319 MemRRow1320 1000.000000
R21320 MemRRow1320 MemRRow1321 1000.000000
R21321 MemRRow1321 MemRRow1322 1000.000000
R21322 MemRRow1322 MemRRow1323 1000.000000
R21323 MemRRow1323 MemRRow1324 1000.000000
R21324 MemRRow1324 MemRRow1325 1000.000000
R21325 MemRRow1325 MemRRow1326 1000.000000
R21326 MemRRow1326 MemRRow1327 1000.000000
R21327 MemRRow1327 MemRRow1328 1000.000000
R21328 MemRRow1328 MemRRow1329 1000.000000
R21329 MemRRow1329 MemRRow1330 1000.000000
R21330 MemRRow1330 MemRRow1331 1000.000000
R21331 MemRRow1331 MemRRow1332 1000.000000
R21332 MemRRow1332 MemRRow1333 1000.000000
R21333 MemRRow1333 MemRRow1334 1000.000000
R21334 MemRRow1334 MemRRow1335 1000.000000
R21335 MemRRow1335 MemRRow1336 1000.000000
R21336 MemRRow1336 MemRRow1337 1000.000000
R21337 MemRRow1337 MemRRow1338 1000.000000
R21338 MemRRow1338 MemRRow1339 1000.000000
R21339 MemRRow1339 MemRRow1340 1000.000000
R21340 MemRRow1340 MemRRow1341 1000.000000
R21341 MemRRow1341 MemRRow1342 1000.000000
R21342 MemRRow1342 MemRRow1343 1000.000000
R21343 MemRRow1343 MemRRow1344 1000.000000
R21344 MemRRow1344 MemRRow1345 1000.000000
R21345 MemRRow1345 MemRRow1346 1000.000000
R21346 MemRRow1346 MemRRow1347 1000.000000
R21347 MemRRow1347 MemRRow1348 1000.000000
R21348 MemRRow1348 MemRRow1349 1000.000000
R21349 MemRRow1349 MemRRow1350 1000.000000
R21350 MemRRow1350 MemRRow1351 1000.000000
R2141 MemRRow141 MemRRow142 1000.000000
R2142 MemRRow142 MemRRow143 1000.000000
R2143 MemRRow143 MemRRow144 1000.000000
R2144 MemRRow144 MemRRow145 1000.000000
R2145 MemRRow145 MemRRow146 1000.000000
R2146 MemRRow146 MemRRow147 1000.000000
R2147 MemRRow147 MemRRow148 1000.000000
R2148 MemRRow148 MemRRow149 1000.000000
R2149 MemRRow149 MemRRow1410 1000.000000
R21410 MemRRow1410 MemRRow1411 1000.000000
R21411 MemRRow1411 MemRRow1412 1000.000000
R21412 MemRRow1412 MemRRow1413 1000.000000
R21413 MemRRow1413 MemRRow1414 1000.000000
R21414 MemRRow1414 MemRRow1415 1000.000000
R21415 MemRRow1415 MemRRow1416 1000.000000
R21416 MemRRow1416 MemRRow1417 1000.000000
R21417 MemRRow1417 MemRRow1418 1000.000000
R21418 MemRRow1418 MemRRow1419 1000.000000
R21419 MemRRow1419 MemRRow1420 1000.000000
R21420 MemRRow1420 MemRRow1421 1000.000000
R21421 MemRRow1421 MemRRow1422 1000.000000
R21422 MemRRow1422 MemRRow1423 1000.000000
R21423 MemRRow1423 MemRRow1424 1000.000000
R21424 MemRRow1424 MemRRow1425 1000.000000
R21425 MemRRow1425 MemRRow1426 1000.000000
R21426 MemRRow1426 MemRRow1427 1000.000000
R21427 MemRRow1427 MemRRow1428 1000.000000
R21428 MemRRow1428 MemRRow1429 1000.000000
R21429 MemRRow1429 MemRRow1430 1000.000000
R21430 MemRRow1430 MemRRow1431 1000.000000
R21431 MemRRow1431 MemRRow1432 1000.000000
R21432 MemRRow1432 MemRRow1433 1000.000000
R21433 MemRRow1433 MemRRow1434 1000.000000
R21434 MemRRow1434 MemRRow1435 1000.000000
R21435 MemRRow1435 MemRRow1436 1000.000000
R21436 MemRRow1436 MemRRow1437 1000.000000
R21437 MemRRow1437 MemRRow1438 1000.000000
R21438 MemRRow1438 MemRRow1439 1000.000000
R21439 MemRRow1439 MemRRow1440 1000.000000
R21440 MemRRow1440 MemRRow1441 1000.000000
R21441 MemRRow1441 MemRRow1442 1000.000000
R21442 MemRRow1442 MemRRow1443 1000.000000
R21443 MemRRow1443 MemRRow1444 1000.000000
R21444 MemRRow1444 MemRRow1445 1000.000000
R21445 MemRRow1445 MemRRow1446 1000.000000
R21446 MemRRow1446 MemRRow1447 1000.000000
R21447 MemRRow1447 MemRRow1448 1000.000000
R21448 MemRRow1448 MemRRow1449 1000.000000
R21449 MemRRow1449 MemRRow1450 1000.000000
R21450 MemRRow1450 MemRRow1451 1000.000000
R2151 MemRRow151 MemRRow152 1000.000000
R2152 MemRRow152 MemRRow153 1000.000000
R2153 MemRRow153 MemRRow154 1000.000000
R2154 MemRRow154 MemRRow155 1000.000000
R2155 MemRRow155 MemRRow156 1000.000000
R2156 MemRRow156 MemRRow157 1000.000000
R2157 MemRRow157 MemRRow158 1000.000000
R2158 MemRRow158 MemRRow159 1000.000000
R2159 MemRRow159 MemRRow1510 1000.000000
R21510 MemRRow1510 MemRRow1511 1000.000000
R21511 MemRRow1511 MemRRow1512 1000.000000
R21512 MemRRow1512 MemRRow1513 1000.000000
R21513 MemRRow1513 MemRRow1514 1000.000000
R21514 MemRRow1514 MemRRow1515 1000.000000
R21515 MemRRow1515 MemRRow1516 1000.000000
R21516 MemRRow1516 MemRRow1517 1000.000000
R21517 MemRRow1517 MemRRow1518 1000.000000
R21518 MemRRow1518 MemRRow1519 1000.000000
R21519 MemRRow1519 MemRRow1520 1000.000000
R21520 MemRRow1520 MemRRow1521 1000.000000
R21521 MemRRow1521 MemRRow1522 1000.000000
R21522 MemRRow1522 MemRRow1523 1000.000000
R21523 MemRRow1523 MemRRow1524 1000.000000
R21524 MemRRow1524 MemRRow1525 1000.000000
R21525 MemRRow1525 MemRRow1526 1000.000000
R21526 MemRRow1526 MemRRow1527 1000.000000
R21527 MemRRow1527 MemRRow1528 1000.000000
R21528 MemRRow1528 MemRRow1529 1000.000000
R21529 MemRRow1529 MemRRow1530 1000.000000
R21530 MemRRow1530 MemRRow1531 1000.000000
R21531 MemRRow1531 MemRRow1532 1000.000000
R21532 MemRRow1532 MemRRow1533 1000.000000
R21533 MemRRow1533 MemRRow1534 1000.000000
R21534 MemRRow1534 MemRRow1535 1000.000000
R21535 MemRRow1535 MemRRow1536 1000.000000
R21536 MemRRow1536 MemRRow1537 1000.000000
R21537 MemRRow1537 MemRRow1538 1000.000000
R21538 MemRRow1538 MemRRow1539 1000.000000
R21539 MemRRow1539 MemRRow1540 1000.000000
R21540 MemRRow1540 MemRRow1541 1000.000000
R21541 MemRRow1541 MemRRow1542 1000.000000
R21542 MemRRow1542 MemRRow1543 1000.000000
R21543 MemRRow1543 MemRRow1544 1000.000000
R21544 MemRRow1544 MemRRow1545 1000.000000
R21545 MemRRow1545 MemRRow1546 1000.000000
R21546 MemRRow1546 MemRRow1547 1000.000000
R21547 MemRRow1547 MemRRow1548 1000.000000
R21548 MemRRow1548 MemRRow1549 1000.000000
R21549 MemRRow1549 MemRRow1550 1000.000000
R21550 MemRRow1550 MemRRow1551 1000.000000
R2161 MemRRow161 MemRRow162 1000.000000
R2162 MemRRow162 MemRRow163 1000.000000
R2163 MemRRow163 MemRRow164 1000.000000
R2164 MemRRow164 MemRRow165 1000.000000
R2165 MemRRow165 MemRRow166 1000.000000
R2166 MemRRow166 MemRRow167 1000.000000
R2167 MemRRow167 MemRRow168 1000.000000
R2168 MemRRow168 MemRRow169 1000.000000
R2169 MemRRow169 MemRRow1610 1000.000000
R21610 MemRRow1610 MemRRow1611 1000.000000
R21611 MemRRow1611 MemRRow1612 1000.000000
R21612 MemRRow1612 MemRRow1613 1000.000000
R21613 MemRRow1613 MemRRow1614 1000.000000
R21614 MemRRow1614 MemRRow1615 1000.000000
R21615 MemRRow1615 MemRRow1616 1000.000000
R21616 MemRRow1616 MemRRow1617 1000.000000
R21617 MemRRow1617 MemRRow1618 1000.000000
R21618 MemRRow1618 MemRRow1619 1000.000000
R21619 MemRRow1619 MemRRow1620 1000.000000
R21620 MemRRow1620 MemRRow1621 1000.000000
R21621 MemRRow1621 MemRRow1622 1000.000000
R21622 MemRRow1622 MemRRow1623 1000.000000
R21623 MemRRow1623 MemRRow1624 1000.000000
R21624 MemRRow1624 MemRRow1625 1000.000000
R21625 MemRRow1625 MemRRow1626 1000.000000
R21626 MemRRow1626 MemRRow1627 1000.000000
R21627 MemRRow1627 MemRRow1628 1000.000000
R21628 MemRRow1628 MemRRow1629 1000.000000
R21629 MemRRow1629 MemRRow1630 1000.000000
R21630 MemRRow1630 MemRRow1631 1000.000000
R21631 MemRRow1631 MemRRow1632 1000.000000
R21632 MemRRow1632 MemRRow1633 1000.000000
R21633 MemRRow1633 MemRRow1634 1000.000000
R21634 MemRRow1634 MemRRow1635 1000.000000
R21635 MemRRow1635 MemRRow1636 1000.000000
R21636 MemRRow1636 MemRRow1637 1000.000000
R21637 MemRRow1637 MemRRow1638 1000.000000
R21638 MemRRow1638 MemRRow1639 1000.000000
R21639 MemRRow1639 MemRRow1640 1000.000000
R21640 MemRRow1640 MemRRow1641 1000.000000
R21641 MemRRow1641 MemRRow1642 1000.000000
R21642 MemRRow1642 MemRRow1643 1000.000000
R21643 MemRRow1643 MemRRow1644 1000.000000
R21644 MemRRow1644 MemRRow1645 1000.000000
R21645 MemRRow1645 MemRRow1646 1000.000000
R21646 MemRRow1646 MemRRow1647 1000.000000
R21647 MemRRow1647 MemRRow1648 1000.000000
R21648 MemRRow1648 MemRRow1649 1000.000000
R21649 MemRRow1649 MemRRow1650 1000.000000
R21650 MemRRow1650 MemRRow1651 1000.000000
R2171 MemRRow171 MemRRow172 1000.000000
R2172 MemRRow172 MemRRow173 1000.000000
R2173 MemRRow173 MemRRow174 1000.000000
R2174 MemRRow174 MemRRow175 1000.000000
R2175 MemRRow175 MemRRow176 1000.000000
R2176 MemRRow176 MemRRow177 1000.000000
R2177 MemRRow177 MemRRow178 1000.000000
R2178 MemRRow178 MemRRow179 1000.000000
R2179 MemRRow179 MemRRow1710 1000.000000
R21710 MemRRow1710 MemRRow1711 1000.000000
R21711 MemRRow1711 MemRRow1712 1000.000000
R21712 MemRRow1712 MemRRow1713 1000.000000
R21713 MemRRow1713 MemRRow1714 1000.000000
R21714 MemRRow1714 MemRRow1715 1000.000000
R21715 MemRRow1715 MemRRow1716 1000.000000
R21716 MemRRow1716 MemRRow1717 1000.000000
R21717 MemRRow1717 MemRRow1718 1000.000000
R21718 MemRRow1718 MemRRow1719 1000.000000
R21719 MemRRow1719 MemRRow1720 1000.000000
R21720 MemRRow1720 MemRRow1721 1000.000000
R21721 MemRRow1721 MemRRow1722 1000.000000
R21722 MemRRow1722 MemRRow1723 1000.000000
R21723 MemRRow1723 MemRRow1724 1000.000000
R21724 MemRRow1724 MemRRow1725 1000.000000
R21725 MemRRow1725 MemRRow1726 1000.000000
R21726 MemRRow1726 MemRRow1727 1000.000000
R21727 MemRRow1727 MemRRow1728 1000.000000
R21728 MemRRow1728 MemRRow1729 1000.000000
R21729 MemRRow1729 MemRRow1730 1000.000000
R21730 MemRRow1730 MemRRow1731 1000.000000
R21731 MemRRow1731 MemRRow1732 1000.000000
R21732 MemRRow1732 MemRRow1733 1000.000000
R21733 MemRRow1733 MemRRow1734 1000.000000
R21734 MemRRow1734 MemRRow1735 1000.000000
R21735 MemRRow1735 MemRRow1736 1000.000000
R21736 MemRRow1736 MemRRow1737 1000.000000
R21737 MemRRow1737 MemRRow1738 1000.000000
R21738 MemRRow1738 MemRRow1739 1000.000000
R21739 MemRRow1739 MemRRow1740 1000.000000
R21740 MemRRow1740 MemRRow1741 1000.000000
R21741 MemRRow1741 MemRRow1742 1000.000000
R21742 MemRRow1742 MemRRow1743 1000.000000
R21743 MemRRow1743 MemRRow1744 1000.000000
R21744 MemRRow1744 MemRRow1745 1000.000000
R21745 MemRRow1745 MemRRow1746 1000.000000
R21746 MemRRow1746 MemRRow1747 1000.000000
R21747 MemRRow1747 MemRRow1748 1000.000000
R21748 MemRRow1748 MemRRow1749 1000.000000
R21749 MemRRow1749 MemRRow1750 1000.000000
R21750 MemRRow1750 MemRRow1751 1000.000000
R2181 MemRRow181 MemRRow182 1000.000000
R2182 MemRRow182 MemRRow183 1000.000000
R2183 MemRRow183 MemRRow184 1000.000000
R2184 MemRRow184 MemRRow185 1000.000000
R2185 MemRRow185 MemRRow186 1000.000000
R2186 MemRRow186 MemRRow187 1000.000000
R2187 MemRRow187 MemRRow188 1000.000000
R2188 MemRRow188 MemRRow189 1000.000000
R2189 MemRRow189 MemRRow1810 1000.000000
R21810 MemRRow1810 MemRRow1811 1000.000000
R21811 MemRRow1811 MemRRow1812 1000.000000
R21812 MemRRow1812 MemRRow1813 1000.000000
R21813 MemRRow1813 MemRRow1814 1000.000000
R21814 MemRRow1814 MemRRow1815 1000.000000
R21815 MemRRow1815 MemRRow1816 1000.000000
R21816 MemRRow1816 MemRRow1817 1000.000000
R21817 MemRRow1817 MemRRow1818 1000.000000
R21818 MemRRow1818 MemRRow1819 1000.000000
R21819 MemRRow1819 MemRRow1820 1000.000000
R21820 MemRRow1820 MemRRow1821 1000.000000
R21821 MemRRow1821 MemRRow1822 1000.000000
R21822 MemRRow1822 MemRRow1823 1000.000000
R21823 MemRRow1823 MemRRow1824 1000.000000
R21824 MemRRow1824 MemRRow1825 1000.000000
R21825 MemRRow1825 MemRRow1826 1000.000000
R21826 MemRRow1826 MemRRow1827 1000.000000
R21827 MemRRow1827 MemRRow1828 1000.000000
R21828 MemRRow1828 MemRRow1829 1000.000000
R21829 MemRRow1829 MemRRow1830 1000.000000
R21830 MemRRow1830 MemRRow1831 1000.000000
R21831 MemRRow1831 MemRRow1832 1000.000000
R21832 MemRRow1832 MemRRow1833 1000.000000
R21833 MemRRow1833 MemRRow1834 1000.000000
R21834 MemRRow1834 MemRRow1835 1000.000000
R21835 MemRRow1835 MemRRow1836 1000.000000
R21836 MemRRow1836 MemRRow1837 1000.000000
R21837 MemRRow1837 MemRRow1838 1000.000000
R21838 MemRRow1838 MemRRow1839 1000.000000
R21839 MemRRow1839 MemRRow1840 1000.000000
R21840 MemRRow1840 MemRRow1841 1000.000000
R21841 MemRRow1841 MemRRow1842 1000.000000
R21842 MemRRow1842 MemRRow1843 1000.000000
R21843 MemRRow1843 MemRRow1844 1000.000000
R21844 MemRRow1844 MemRRow1845 1000.000000
R21845 MemRRow1845 MemRRow1846 1000.000000
R21846 MemRRow1846 MemRRow1847 1000.000000
R21847 MemRRow1847 MemRRow1848 1000.000000
R21848 MemRRow1848 MemRRow1849 1000.000000
R21849 MemRRow1849 MemRRow1850 1000.000000
R21850 MemRRow1850 MemRRow1851 1000.000000
R2191 MemRRow191 MemRRow192 1000.000000
R2192 MemRRow192 MemRRow193 1000.000000
R2193 MemRRow193 MemRRow194 1000.000000
R2194 MemRRow194 MemRRow195 1000.000000
R2195 MemRRow195 MemRRow196 1000.000000
R2196 MemRRow196 MemRRow197 1000.000000
R2197 MemRRow197 MemRRow198 1000.000000
R2198 MemRRow198 MemRRow199 1000.000000
R2199 MemRRow199 MemRRow1910 1000.000000
R21910 MemRRow1910 MemRRow1911 1000.000000
R21911 MemRRow1911 MemRRow1912 1000.000000
R21912 MemRRow1912 MemRRow1913 1000.000000
R21913 MemRRow1913 MemRRow1914 1000.000000
R21914 MemRRow1914 MemRRow1915 1000.000000
R21915 MemRRow1915 MemRRow1916 1000.000000
R21916 MemRRow1916 MemRRow1917 1000.000000
R21917 MemRRow1917 MemRRow1918 1000.000000
R21918 MemRRow1918 MemRRow1919 1000.000000
R21919 MemRRow1919 MemRRow1920 1000.000000
R21920 MemRRow1920 MemRRow1921 1000.000000
R21921 MemRRow1921 MemRRow1922 1000.000000
R21922 MemRRow1922 MemRRow1923 1000.000000
R21923 MemRRow1923 MemRRow1924 1000.000000
R21924 MemRRow1924 MemRRow1925 1000.000000
R21925 MemRRow1925 MemRRow1926 1000.000000
R21926 MemRRow1926 MemRRow1927 1000.000000
R21927 MemRRow1927 MemRRow1928 1000.000000
R21928 MemRRow1928 MemRRow1929 1000.000000
R21929 MemRRow1929 MemRRow1930 1000.000000
R21930 MemRRow1930 MemRRow1931 1000.000000
R21931 MemRRow1931 MemRRow1932 1000.000000
R21932 MemRRow1932 MemRRow1933 1000.000000
R21933 MemRRow1933 MemRRow1934 1000.000000
R21934 MemRRow1934 MemRRow1935 1000.000000
R21935 MemRRow1935 MemRRow1936 1000.000000
R21936 MemRRow1936 MemRRow1937 1000.000000
R21937 MemRRow1937 MemRRow1938 1000.000000
R21938 MemRRow1938 MemRRow1939 1000.000000
R21939 MemRRow1939 MemRRow1940 1000.000000
R21940 MemRRow1940 MemRRow1941 1000.000000
R21941 MemRRow1941 MemRRow1942 1000.000000
R21942 MemRRow1942 MemRRow1943 1000.000000
R21943 MemRRow1943 MemRRow1944 1000.000000
R21944 MemRRow1944 MemRRow1945 1000.000000
R21945 MemRRow1945 MemRRow1946 1000.000000
R21946 MemRRow1946 MemRRow1947 1000.000000
R21947 MemRRow1947 MemRRow1948 1000.000000
R21948 MemRRow1948 MemRRow1949 1000.000000
R21949 MemRRow1949 MemRRow1950 1000.000000
R21950 MemRRow1950 MemRRow1951 1000.000000
R2201 MemRRow201 MemRRow202 1000.000000
R2202 MemRRow202 MemRRow203 1000.000000
R2203 MemRRow203 MemRRow204 1000.000000
R2204 MemRRow204 MemRRow205 1000.000000
R2205 MemRRow205 MemRRow206 1000.000000
R2206 MemRRow206 MemRRow207 1000.000000
R2207 MemRRow207 MemRRow208 1000.000000
R2208 MemRRow208 MemRRow209 1000.000000
R2209 MemRRow209 MemRRow2010 1000.000000
R22010 MemRRow2010 MemRRow2011 1000.000000
R22011 MemRRow2011 MemRRow2012 1000.000000
R22012 MemRRow2012 MemRRow2013 1000.000000
R22013 MemRRow2013 MemRRow2014 1000.000000
R22014 MemRRow2014 MemRRow2015 1000.000000
R22015 MemRRow2015 MemRRow2016 1000.000000
R22016 MemRRow2016 MemRRow2017 1000.000000
R22017 MemRRow2017 MemRRow2018 1000.000000
R22018 MemRRow2018 MemRRow2019 1000.000000
R22019 MemRRow2019 MemRRow2020 1000.000000
R22020 MemRRow2020 MemRRow2021 1000.000000
R22021 MemRRow2021 MemRRow2022 1000.000000
R22022 MemRRow2022 MemRRow2023 1000.000000
R22023 MemRRow2023 MemRRow2024 1000.000000
R22024 MemRRow2024 MemRRow2025 1000.000000
R22025 MemRRow2025 MemRRow2026 1000.000000
R22026 MemRRow2026 MemRRow2027 1000.000000
R22027 MemRRow2027 MemRRow2028 1000.000000
R22028 MemRRow2028 MemRRow2029 1000.000000
R22029 MemRRow2029 MemRRow2030 1000.000000
R22030 MemRRow2030 MemRRow2031 1000.000000
R22031 MemRRow2031 MemRRow2032 1000.000000
R22032 MemRRow2032 MemRRow2033 1000.000000
R22033 MemRRow2033 MemRRow2034 1000.000000
R22034 MemRRow2034 MemRRow2035 1000.000000
R22035 MemRRow2035 MemRRow2036 1000.000000
R22036 MemRRow2036 MemRRow2037 1000.000000
R22037 MemRRow2037 MemRRow2038 1000.000000
R22038 MemRRow2038 MemRRow2039 1000.000000
R22039 MemRRow2039 MemRRow2040 1000.000000
R22040 MemRRow2040 MemRRow2041 1000.000000
R22041 MemRRow2041 MemRRow2042 1000.000000
R22042 MemRRow2042 MemRRow2043 1000.000000
R22043 MemRRow2043 MemRRow2044 1000.000000
R22044 MemRRow2044 MemRRow2045 1000.000000
R22045 MemRRow2045 MemRRow2046 1000.000000
R22046 MemRRow2046 MemRRow2047 1000.000000
R22047 MemRRow2047 MemRRow2048 1000.000000
R22048 MemRRow2048 MemRRow2049 1000.000000
R22049 MemRRow2049 MemRRow2050 1000.000000
R22050 MemRRow2050 MemRRow2051 1000.000000
R2211 MemRRow211 MemRRow212 1000.000000
R2212 MemRRow212 MemRRow213 1000.000000
R2213 MemRRow213 MemRRow214 1000.000000
R2214 MemRRow214 MemRRow215 1000.000000
R2215 MemRRow215 MemRRow216 1000.000000
R2216 MemRRow216 MemRRow217 1000.000000
R2217 MemRRow217 MemRRow218 1000.000000
R2218 MemRRow218 MemRRow219 1000.000000
R2219 MemRRow219 MemRRow2110 1000.000000
R22110 MemRRow2110 MemRRow2111 1000.000000
R22111 MemRRow2111 MemRRow2112 1000.000000
R22112 MemRRow2112 MemRRow2113 1000.000000
R22113 MemRRow2113 MemRRow2114 1000.000000
R22114 MemRRow2114 MemRRow2115 1000.000000
R22115 MemRRow2115 MemRRow2116 1000.000000
R22116 MemRRow2116 MemRRow2117 1000.000000
R22117 MemRRow2117 MemRRow2118 1000.000000
R22118 MemRRow2118 MemRRow2119 1000.000000
R22119 MemRRow2119 MemRRow2120 1000.000000
R22120 MemRRow2120 MemRRow2121 1000.000000
R22121 MemRRow2121 MemRRow2122 1000.000000
R22122 MemRRow2122 MemRRow2123 1000.000000
R22123 MemRRow2123 MemRRow2124 1000.000000
R22124 MemRRow2124 MemRRow2125 1000.000000
R22125 MemRRow2125 MemRRow2126 1000.000000
R22126 MemRRow2126 MemRRow2127 1000.000000
R22127 MemRRow2127 MemRRow2128 1000.000000
R22128 MemRRow2128 MemRRow2129 1000.000000
R22129 MemRRow2129 MemRRow2130 1000.000000
R22130 MemRRow2130 MemRRow2131 1000.000000
R22131 MemRRow2131 MemRRow2132 1000.000000
R22132 MemRRow2132 MemRRow2133 1000.000000
R22133 MemRRow2133 MemRRow2134 1000.000000
R22134 MemRRow2134 MemRRow2135 1000.000000
R22135 MemRRow2135 MemRRow2136 1000.000000
R22136 MemRRow2136 MemRRow2137 1000.000000
R22137 MemRRow2137 MemRRow2138 1000.000000
R22138 MemRRow2138 MemRRow2139 1000.000000
R22139 MemRRow2139 MemRRow2140 1000.000000
R22140 MemRRow2140 MemRRow2141 1000.000000
R22141 MemRRow2141 MemRRow2142 1000.000000
R22142 MemRRow2142 MemRRow2143 1000.000000
R22143 MemRRow2143 MemRRow2144 1000.000000
R22144 MemRRow2144 MemRRow2145 1000.000000
R22145 MemRRow2145 MemRRow2146 1000.000000
R22146 MemRRow2146 MemRRow2147 1000.000000
R22147 MemRRow2147 MemRRow2148 1000.000000
R22148 MemRRow2148 MemRRow2149 1000.000000
R22149 MemRRow2149 MemRRow2150 1000.000000
R22150 MemRRow2150 MemRRow2151 1000.000000
R2221 MemRRow221 MemRRow222 1000.000000
R2222 MemRRow222 MemRRow223 1000.000000
R2223 MemRRow223 MemRRow224 1000.000000
R2224 MemRRow224 MemRRow225 1000.000000
R2225 MemRRow225 MemRRow226 1000.000000
R2226 MemRRow226 MemRRow227 1000.000000
R2227 MemRRow227 MemRRow228 1000.000000
R2228 MemRRow228 MemRRow229 1000.000000
R2229 MemRRow229 MemRRow2210 1000.000000
R22210 MemRRow2210 MemRRow2211 1000.000000
R22211 MemRRow2211 MemRRow2212 1000.000000
R22212 MemRRow2212 MemRRow2213 1000.000000
R22213 MemRRow2213 MemRRow2214 1000.000000
R22214 MemRRow2214 MemRRow2215 1000.000000
R22215 MemRRow2215 MemRRow2216 1000.000000
R22216 MemRRow2216 MemRRow2217 1000.000000
R22217 MemRRow2217 MemRRow2218 1000.000000
R22218 MemRRow2218 MemRRow2219 1000.000000
R22219 MemRRow2219 MemRRow2220 1000.000000
R22220 MemRRow2220 MemRRow2221 1000.000000
R22221 MemRRow2221 MemRRow2222 1000.000000
R22222 MemRRow2222 MemRRow2223 1000.000000
R22223 MemRRow2223 MemRRow2224 1000.000000
R22224 MemRRow2224 MemRRow2225 1000.000000
R22225 MemRRow2225 MemRRow2226 1000.000000
R22226 MemRRow2226 MemRRow2227 1000.000000
R22227 MemRRow2227 MemRRow2228 1000.000000
R22228 MemRRow2228 MemRRow2229 1000.000000
R22229 MemRRow2229 MemRRow2230 1000.000000
R22230 MemRRow2230 MemRRow2231 1000.000000
R22231 MemRRow2231 MemRRow2232 1000.000000
R22232 MemRRow2232 MemRRow2233 1000.000000
R22233 MemRRow2233 MemRRow2234 1000.000000
R22234 MemRRow2234 MemRRow2235 1000.000000
R22235 MemRRow2235 MemRRow2236 1000.000000
R22236 MemRRow2236 MemRRow2237 1000.000000
R22237 MemRRow2237 MemRRow2238 1000.000000
R22238 MemRRow2238 MemRRow2239 1000.000000
R22239 MemRRow2239 MemRRow2240 1000.000000
R22240 MemRRow2240 MemRRow2241 1000.000000
R22241 MemRRow2241 MemRRow2242 1000.000000
R22242 MemRRow2242 MemRRow2243 1000.000000
R22243 MemRRow2243 MemRRow2244 1000.000000
R22244 MemRRow2244 MemRRow2245 1000.000000
R22245 MemRRow2245 MemRRow2246 1000.000000
R22246 MemRRow2246 MemRRow2247 1000.000000
R22247 MemRRow2247 MemRRow2248 1000.000000
R22248 MemRRow2248 MemRRow2249 1000.000000
R22249 MemRRow2249 MemRRow2250 1000.000000
R22250 MemRRow2250 MemRRow2251 1000.000000
R2231 MemRRow231 MemRRow232 1000.000000
R2232 MemRRow232 MemRRow233 1000.000000
R2233 MemRRow233 MemRRow234 1000.000000
R2234 MemRRow234 MemRRow235 1000.000000
R2235 MemRRow235 MemRRow236 1000.000000
R2236 MemRRow236 MemRRow237 1000.000000
R2237 MemRRow237 MemRRow238 1000.000000
R2238 MemRRow238 MemRRow239 1000.000000
R2239 MemRRow239 MemRRow2310 1000.000000
R22310 MemRRow2310 MemRRow2311 1000.000000
R22311 MemRRow2311 MemRRow2312 1000.000000
R22312 MemRRow2312 MemRRow2313 1000.000000
R22313 MemRRow2313 MemRRow2314 1000.000000
R22314 MemRRow2314 MemRRow2315 1000.000000
R22315 MemRRow2315 MemRRow2316 1000.000000
R22316 MemRRow2316 MemRRow2317 1000.000000
R22317 MemRRow2317 MemRRow2318 1000.000000
R22318 MemRRow2318 MemRRow2319 1000.000000
R22319 MemRRow2319 MemRRow2320 1000.000000
R22320 MemRRow2320 MemRRow2321 1000.000000
R22321 MemRRow2321 MemRRow2322 1000.000000
R22322 MemRRow2322 MemRRow2323 1000.000000
R22323 MemRRow2323 MemRRow2324 1000.000000
R22324 MemRRow2324 MemRRow2325 1000.000000
R22325 MemRRow2325 MemRRow2326 1000.000000
R22326 MemRRow2326 MemRRow2327 1000.000000
R22327 MemRRow2327 MemRRow2328 1000.000000
R22328 MemRRow2328 MemRRow2329 1000.000000
R22329 MemRRow2329 MemRRow2330 1000.000000
R22330 MemRRow2330 MemRRow2331 1000.000000
R22331 MemRRow2331 MemRRow2332 1000.000000
R22332 MemRRow2332 MemRRow2333 1000.000000
R22333 MemRRow2333 MemRRow2334 1000.000000
R22334 MemRRow2334 MemRRow2335 1000.000000
R22335 MemRRow2335 MemRRow2336 1000.000000
R22336 MemRRow2336 MemRRow2337 1000.000000
R22337 MemRRow2337 MemRRow2338 1000.000000
R22338 MemRRow2338 MemRRow2339 1000.000000
R22339 MemRRow2339 MemRRow2340 1000.000000
R22340 MemRRow2340 MemRRow2341 1000.000000
R22341 MemRRow2341 MemRRow2342 1000.000000
R22342 MemRRow2342 MemRRow2343 1000.000000
R22343 MemRRow2343 MemRRow2344 1000.000000
R22344 MemRRow2344 MemRRow2345 1000.000000
R22345 MemRRow2345 MemRRow2346 1000.000000
R22346 MemRRow2346 MemRRow2347 1000.000000
R22347 MemRRow2347 MemRRow2348 1000.000000
R22348 MemRRow2348 MemRRow2349 1000.000000
R22349 MemRRow2349 MemRRow2350 1000.000000
R22350 MemRRow2350 MemRRow2351 1000.000000
R2241 MemRRow241 MemRRow242 1000.000000
R2242 MemRRow242 MemRRow243 1000.000000
R2243 MemRRow243 MemRRow244 1000.000000
R2244 MemRRow244 MemRRow245 1000.000000
R2245 MemRRow245 MemRRow246 1000.000000
R2246 MemRRow246 MemRRow247 1000.000000
R2247 MemRRow247 MemRRow248 1000.000000
R2248 MemRRow248 MemRRow249 1000.000000
R2249 MemRRow249 MemRRow2410 1000.000000
R22410 MemRRow2410 MemRRow2411 1000.000000
R22411 MemRRow2411 MemRRow2412 1000.000000
R22412 MemRRow2412 MemRRow2413 1000.000000
R22413 MemRRow2413 MemRRow2414 1000.000000
R22414 MemRRow2414 MemRRow2415 1000.000000
R22415 MemRRow2415 MemRRow2416 1000.000000
R22416 MemRRow2416 MemRRow2417 1000.000000
R22417 MemRRow2417 MemRRow2418 1000.000000
R22418 MemRRow2418 MemRRow2419 1000.000000
R22419 MemRRow2419 MemRRow2420 1000.000000
R22420 MemRRow2420 MemRRow2421 1000.000000
R22421 MemRRow2421 MemRRow2422 1000.000000
R22422 MemRRow2422 MemRRow2423 1000.000000
R22423 MemRRow2423 MemRRow2424 1000.000000
R22424 MemRRow2424 MemRRow2425 1000.000000
R22425 MemRRow2425 MemRRow2426 1000.000000
R22426 MemRRow2426 MemRRow2427 1000.000000
R22427 MemRRow2427 MemRRow2428 1000.000000
R22428 MemRRow2428 MemRRow2429 1000.000000
R22429 MemRRow2429 MemRRow2430 1000.000000
R22430 MemRRow2430 MemRRow2431 1000.000000
R22431 MemRRow2431 MemRRow2432 1000.000000
R22432 MemRRow2432 MemRRow2433 1000.000000
R22433 MemRRow2433 MemRRow2434 1000.000000
R22434 MemRRow2434 MemRRow2435 1000.000000
R22435 MemRRow2435 MemRRow2436 1000.000000
R22436 MemRRow2436 MemRRow2437 1000.000000
R22437 MemRRow2437 MemRRow2438 1000.000000
R22438 MemRRow2438 MemRRow2439 1000.000000
R22439 MemRRow2439 MemRRow2440 1000.000000
R22440 MemRRow2440 MemRRow2441 1000.000000
R22441 MemRRow2441 MemRRow2442 1000.000000
R22442 MemRRow2442 MemRRow2443 1000.000000
R22443 MemRRow2443 MemRRow2444 1000.000000
R22444 MemRRow2444 MemRRow2445 1000.000000
R22445 MemRRow2445 MemRRow2446 1000.000000
R22446 MemRRow2446 MemRRow2447 1000.000000
R22447 MemRRow2447 MemRRow2448 1000.000000
R22448 MemRRow2448 MemRRow2449 1000.000000
R22449 MemRRow2449 MemRRow2450 1000.000000
R22450 MemRRow2450 MemRRow2451 1000.000000
R2251 MemRRow251 MemRRow252 1000.000000
R2252 MemRRow252 MemRRow253 1000.000000
R2253 MemRRow253 MemRRow254 1000.000000
R2254 MemRRow254 MemRRow255 1000.000000
R2255 MemRRow255 MemRRow256 1000.000000
R2256 MemRRow256 MemRRow257 1000.000000
R2257 MemRRow257 MemRRow258 1000.000000
R2258 MemRRow258 MemRRow259 1000.000000
R2259 MemRRow259 MemRRow2510 1000.000000
R22510 MemRRow2510 MemRRow2511 1000.000000
R22511 MemRRow2511 MemRRow2512 1000.000000
R22512 MemRRow2512 MemRRow2513 1000.000000
R22513 MemRRow2513 MemRRow2514 1000.000000
R22514 MemRRow2514 MemRRow2515 1000.000000
R22515 MemRRow2515 MemRRow2516 1000.000000
R22516 MemRRow2516 MemRRow2517 1000.000000
R22517 MemRRow2517 MemRRow2518 1000.000000
R22518 MemRRow2518 MemRRow2519 1000.000000
R22519 MemRRow2519 MemRRow2520 1000.000000
R22520 MemRRow2520 MemRRow2521 1000.000000
R22521 MemRRow2521 MemRRow2522 1000.000000
R22522 MemRRow2522 MemRRow2523 1000.000000
R22523 MemRRow2523 MemRRow2524 1000.000000
R22524 MemRRow2524 MemRRow2525 1000.000000
R22525 MemRRow2525 MemRRow2526 1000.000000
R22526 MemRRow2526 MemRRow2527 1000.000000
R22527 MemRRow2527 MemRRow2528 1000.000000
R22528 MemRRow2528 MemRRow2529 1000.000000
R22529 MemRRow2529 MemRRow2530 1000.000000
R22530 MemRRow2530 MemRRow2531 1000.000000
R22531 MemRRow2531 MemRRow2532 1000.000000
R22532 MemRRow2532 MemRRow2533 1000.000000
R22533 MemRRow2533 MemRRow2534 1000.000000
R22534 MemRRow2534 MemRRow2535 1000.000000
R22535 MemRRow2535 MemRRow2536 1000.000000
R22536 MemRRow2536 MemRRow2537 1000.000000
R22537 MemRRow2537 MemRRow2538 1000.000000
R22538 MemRRow2538 MemRRow2539 1000.000000
R22539 MemRRow2539 MemRRow2540 1000.000000
R22540 MemRRow2540 MemRRow2541 1000.000000
R22541 MemRRow2541 MemRRow2542 1000.000000
R22542 MemRRow2542 MemRRow2543 1000.000000
R22543 MemRRow2543 MemRRow2544 1000.000000
R22544 MemRRow2544 MemRRow2545 1000.000000
R22545 MemRRow2545 MemRRow2546 1000.000000
R22546 MemRRow2546 MemRRow2547 1000.000000
R22547 MemRRow2547 MemRRow2548 1000.000000
R22548 MemRRow2548 MemRRow2549 1000.000000
R22549 MemRRow2549 MemRRow2550 1000.000000
R22550 MemRRow2550 MemRRow2551 1000.000000
R2261 MemRRow261 MemRRow262 1000.000000
R2262 MemRRow262 MemRRow263 1000.000000
R2263 MemRRow263 MemRRow264 1000.000000
R2264 MemRRow264 MemRRow265 1000.000000
R2265 MemRRow265 MemRRow266 1000.000000
R2266 MemRRow266 MemRRow267 1000.000000
R2267 MemRRow267 MemRRow268 1000.000000
R2268 MemRRow268 MemRRow269 1000.000000
R2269 MemRRow269 MemRRow2610 1000.000000
R22610 MemRRow2610 MemRRow2611 1000.000000
R22611 MemRRow2611 MemRRow2612 1000.000000
R22612 MemRRow2612 MemRRow2613 1000.000000
R22613 MemRRow2613 MemRRow2614 1000.000000
R22614 MemRRow2614 MemRRow2615 1000.000000
R22615 MemRRow2615 MemRRow2616 1000.000000
R22616 MemRRow2616 MemRRow2617 1000.000000
R22617 MemRRow2617 MemRRow2618 1000.000000
R22618 MemRRow2618 MemRRow2619 1000.000000
R22619 MemRRow2619 MemRRow2620 1000.000000
R22620 MemRRow2620 MemRRow2621 1000.000000
R22621 MemRRow2621 MemRRow2622 1000.000000
R22622 MemRRow2622 MemRRow2623 1000.000000
R22623 MemRRow2623 MemRRow2624 1000.000000
R22624 MemRRow2624 MemRRow2625 1000.000000
R22625 MemRRow2625 MemRRow2626 1000.000000
R22626 MemRRow2626 MemRRow2627 1000.000000
R22627 MemRRow2627 MemRRow2628 1000.000000
R22628 MemRRow2628 MemRRow2629 1000.000000
R22629 MemRRow2629 MemRRow2630 1000.000000
R22630 MemRRow2630 MemRRow2631 1000.000000
R22631 MemRRow2631 MemRRow2632 1000.000000
R22632 MemRRow2632 MemRRow2633 1000.000000
R22633 MemRRow2633 MemRRow2634 1000.000000
R22634 MemRRow2634 MemRRow2635 1000.000000
R22635 MemRRow2635 MemRRow2636 1000.000000
R22636 MemRRow2636 MemRRow2637 1000.000000
R22637 MemRRow2637 MemRRow2638 1000.000000
R22638 MemRRow2638 MemRRow2639 1000.000000
R22639 MemRRow2639 MemRRow2640 1000.000000
R22640 MemRRow2640 MemRRow2641 1000.000000
R22641 MemRRow2641 MemRRow2642 1000.000000
R22642 MemRRow2642 MemRRow2643 1000.000000
R22643 MemRRow2643 MemRRow2644 1000.000000
R22644 MemRRow2644 MemRRow2645 1000.000000
R22645 MemRRow2645 MemRRow2646 1000.000000
R22646 MemRRow2646 MemRRow2647 1000.000000
R22647 MemRRow2647 MemRRow2648 1000.000000
R22648 MemRRow2648 MemRRow2649 1000.000000
R22649 MemRRow2649 MemRRow2650 1000.000000
R22650 MemRRow2650 MemRRow2651 1000.000000
R2271 MemRRow271 MemRRow272 1000.000000
R2272 MemRRow272 MemRRow273 1000.000000
R2273 MemRRow273 MemRRow274 1000.000000
R2274 MemRRow274 MemRRow275 1000.000000
R2275 MemRRow275 MemRRow276 1000.000000
R2276 MemRRow276 MemRRow277 1000.000000
R2277 MemRRow277 MemRRow278 1000.000000
R2278 MemRRow278 MemRRow279 1000.000000
R2279 MemRRow279 MemRRow2710 1000.000000
R22710 MemRRow2710 MemRRow2711 1000.000000
R22711 MemRRow2711 MemRRow2712 1000.000000
R22712 MemRRow2712 MemRRow2713 1000.000000
R22713 MemRRow2713 MemRRow2714 1000.000000
R22714 MemRRow2714 MemRRow2715 1000.000000
R22715 MemRRow2715 MemRRow2716 1000.000000
R22716 MemRRow2716 MemRRow2717 1000.000000
R22717 MemRRow2717 MemRRow2718 1000.000000
R22718 MemRRow2718 MemRRow2719 1000.000000
R22719 MemRRow2719 MemRRow2720 1000.000000
R22720 MemRRow2720 MemRRow2721 1000.000000
R22721 MemRRow2721 MemRRow2722 1000.000000
R22722 MemRRow2722 MemRRow2723 1000.000000
R22723 MemRRow2723 MemRRow2724 1000.000000
R22724 MemRRow2724 MemRRow2725 1000.000000
R22725 MemRRow2725 MemRRow2726 1000.000000
R22726 MemRRow2726 MemRRow2727 1000.000000
R22727 MemRRow2727 MemRRow2728 1000.000000
R22728 MemRRow2728 MemRRow2729 1000.000000
R22729 MemRRow2729 MemRRow2730 1000.000000
R22730 MemRRow2730 MemRRow2731 1000.000000
R22731 MemRRow2731 MemRRow2732 1000.000000
R22732 MemRRow2732 MemRRow2733 1000.000000
R22733 MemRRow2733 MemRRow2734 1000.000000
R22734 MemRRow2734 MemRRow2735 1000.000000
R22735 MemRRow2735 MemRRow2736 1000.000000
R22736 MemRRow2736 MemRRow2737 1000.000000
R22737 MemRRow2737 MemRRow2738 1000.000000
R22738 MemRRow2738 MemRRow2739 1000.000000
R22739 MemRRow2739 MemRRow2740 1000.000000
R22740 MemRRow2740 MemRRow2741 1000.000000
R22741 MemRRow2741 MemRRow2742 1000.000000
R22742 MemRRow2742 MemRRow2743 1000.000000
R22743 MemRRow2743 MemRRow2744 1000.000000
R22744 MemRRow2744 MemRRow2745 1000.000000
R22745 MemRRow2745 MemRRow2746 1000.000000
R22746 MemRRow2746 MemRRow2747 1000.000000
R22747 MemRRow2747 MemRRow2748 1000.000000
R22748 MemRRow2748 MemRRow2749 1000.000000
R22749 MemRRow2749 MemRRow2750 1000.000000
R22750 MemRRow2750 MemRRow2751 1000.000000
R2281 MemRRow281 MemRRow282 1000.000000
R2282 MemRRow282 MemRRow283 1000.000000
R2283 MemRRow283 MemRRow284 1000.000000
R2284 MemRRow284 MemRRow285 1000.000000
R2285 MemRRow285 MemRRow286 1000.000000
R2286 MemRRow286 MemRRow287 1000.000000
R2287 MemRRow287 MemRRow288 1000.000000
R2288 MemRRow288 MemRRow289 1000.000000
R2289 MemRRow289 MemRRow2810 1000.000000
R22810 MemRRow2810 MemRRow2811 1000.000000
R22811 MemRRow2811 MemRRow2812 1000.000000
R22812 MemRRow2812 MemRRow2813 1000.000000
R22813 MemRRow2813 MemRRow2814 1000.000000
R22814 MemRRow2814 MemRRow2815 1000.000000
R22815 MemRRow2815 MemRRow2816 1000.000000
R22816 MemRRow2816 MemRRow2817 1000.000000
R22817 MemRRow2817 MemRRow2818 1000.000000
R22818 MemRRow2818 MemRRow2819 1000.000000
R22819 MemRRow2819 MemRRow2820 1000.000000
R22820 MemRRow2820 MemRRow2821 1000.000000
R22821 MemRRow2821 MemRRow2822 1000.000000
R22822 MemRRow2822 MemRRow2823 1000.000000
R22823 MemRRow2823 MemRRow2824 1000.000000
R22824 MemRRow2824 MemRRow2825 1000.000000
R22825 MemRRow2825 MemRRow2826 1000.000000
R22826 MemRRow2826 MemRRow2827 1000.000000
R22827 MemRRow2827 MemRRow2828 1000.000000
R22828 MemRRow2828 MemRRow2829 1000.000000
R22829 MemRRow2829 MemRRow2830 1000.000000
R22830 MemRRow2830 MemRRow2831 1000.000000
R22831 MemRRow2831 MemRRow2832 1000.000000
R22832 MemRRow2832 MemRRow2833 1000.000000
R22833 MemRRow2833 MemRRow2834 1000.000000
R22834 MemRRow2834 MemRRow2835 1000.000000
R22835 MemRRow2835 MemRRow2836 1000.000000
R22836 MemRRow2836 MemRRow2837 1000.000000
R22837 MemRRow2837 MemRRow2838 1000.000000
R22838 MemRRow2838 MemRRow2839 1000.000000
R22839 MemRRow2839 MemRRow2840 1000.000000
R22840 MemRRow2840 MemRRow2841 1000.000000
R22841 MemRRow2841 MemRRow2842 1000.000000
R22842 MemRRow2842 MemRRow2843 1000.000000
R22843 MemRRow2843 MemRRow2844 1000.000000
R22844 MemRRow2844 MemRRow2845 1000.000000
R22845 MemRRow2845 MemRRow2846 1000.000000
R22846 MemRRow2846 MemRRow2847 1000.000000
R22847 MemRRow2847 MemRRow2848 1000.000000
R22848 MemRRow2848 MemRRow2849 1000.000000
R22849 MemRRow2849 MemRRow2850 1000.000000
R22850 MemRRow2850 MemRRow2851 1000.000000
R2291 MemRRow291 MemRRow292 1000.000000
R2292 MemRRow292 MemRRow293 1000.000000
R2293 MemRRow293 MemRRow294 1000.000000
R2294 MemRRow294 MemRRow295 1000.000000
R2295 MemRRow295 MemRRow296 1000.000000
R2296 MemRRow296 MemRRow297 1000.000000
R2297 MemRRow297 MemRRow298 1000.000000
R2298 MemRRow298 MemRRow299 1000.000000
R2299 MemRRow299 MemRRow2910 1000.000000
R22910 MemRRow2910 MemRRow2911 1000.000000
R22911 MemRRow2911 MemRRow2912 1000.000000
R22912 MemRRow2912 MemRRow2913 1000.000000
R22913 MemRRow2913 MemRRow2914 1000.000000
R22914 MemRRow2914 MemRRow2915 1000.000000
R22915 MemRRow2915 MemRRow2916 1000.000000
R22916 MemRRow2916 MemRRow2917 1000.000000
R22917 MemRRow2917 MemRRow2918 1000.000000
R22918 MemRRow2918 MemRRow2919 1000.000000
R22919 MemRRow2919 MemRRow2920 1000.000000
R22920 MemRRow2920 MemRRow2921 1000.000000
R22921 MemRRow2921 MemRRow2922 1000.000000
R22922 MemRRow2922 MemRRow2923 1000.000000
R22923 MemRRow2923 MemRRow2924 1000.000000
R22924 MemRRow2924 MemRRow2925 1000.000000
R22925 MemRRow2925 MemRRow2926 1000.000000
R22926 MemRRow2926 MemRRow2927 1000.000000
R22927 MemRRow2927 MemRRow2928 1000.000000
R22928 MemRRow2928 MemRRow2929 1000.000000
R22929 MemRRow2929 MemRRow2930 1000.000000
R22930 MemRRow2930 MemRRow2931 1000.000000
R22931 MemRRow2931 MemRRow2932 1000.000000
R22932 MemRRow2932 MemRRow2933 1000.000000
R22933 MemRRow2933 MemRRow2934 1000.000000
R22934 MemRRow2934 MemRRow2935 1000.000000
R22935 MemRRow2935 MemRRow2936 1000.000000
R22936 MemRRow2936 MemRRow2937 1000.000000
R22937 MemRRow2937 MemRRow2938 1000.000000
R22938 MemRRow2938 MemRRow2939 1000.000000
R22939 MemRRow2939 MemRRow2940 1000.000000
R22940 MemRRow2940 MemRRow2941 1000.000000
R22941 MemRRow2941 MemRRow2942 1000.000000
R22942 MemRRow2942 MemRRow2943 1000.000000
R22943 MemRRow2943 MemRRow2944 1000.000000
R22944 MemRRow2944 MemRRow2945 1000.000000
R22945 MemRRow2945 MemRRow2946 1000.000000
R22946 MemRRow2946 MemRRow2947 1000.000000
R22947 MemRRow2947 MemRRow2948 1000.000000
R22948 MemRRow2948 MemRRow2949 1000.000000
R22949 MemRRow2949 MemRRow2950 1000.000000
R22950 MemRRow2950 MemRRow2951 1000.000000
R2301 MemRRow301 MemRRow302 1000.000000
R2302 MemRRow302 MemRRow303 1000.000000
R2303 MemRRow303 MemRRow304 1000.000000
R2304 MemRRow304 MemRRow305 1000.000000
R2305 MemRRow305 MemRRow306 1000.000000
R2306 MemRRow306 MemRRow307 1000.000000
R2307 MemRRow307 MemRRow308 1000.000000
R2308 MemRRow308 MemRRow309 1000.000000
R2309 MemRRow309 MemRRow3010 1000.000000
R23010 MemRRow3010 MemRRow3011 1000.000000
R23011 MemRRow3011 MemRRow3012 1000.000000
R23012 MemRRow3012 MemRRow3013 1000.000000
R23013 MemRRow3013 MemRRow3014 1000.000000
R23014 MemRRow3014 MemRRow3015 1000.000000
R23015 MemRRow3015 MemRRow3016 1000.000000
R23016 MemRRow3016 MemRRow3017 1000.000000
R23017 MemRRow3017 MemRRow3018 1000.000000
R23018 MemRRow3018 MemRRow3019 1000.000000
R23019 MemRRow3019 MemRRow3020 1000.000000
R23020 MemRRow3020 MemRRow3021 1000.000000
R23021 MemRRow3021 MemRRow3022 1000.000000
R23022 MemRRow3022 MemRRow3023 1000.000000
R23023 MemRRow3023 MemRRow3024 1000.000000
R23024 MemRRow3024 MemRRow3025 1000.000000
R23025 MemRRow3025 MemRRow3026 1000.000000
R23026 MemRRow3026 MemRRow3027 1000.000000
R23027 MemRRow3027 MemRRow3028 1000.000000
R23028 MemRRow3028 MemRRow3029 1000.000000
R23029 MemRRow3029 MemRRow3030 1000.000000
R23030 MemRRow3030 MemRRow3031 1000.000000
R23031 MemRRow3031 MemRRow3032 1000.000000
R23032 MemRRow3032 MemRRow3033 1000.000000
R23033 MemRRow3033 MemRRow3034 1000.000000
R23034 MemRRow3034 MemRRow3035 1000.000000
R23035 MemRRow3035 MemRRow3036 1000.000000
R23036 MemRRow3036 MemRRow3037 1000.000000
R23037 MemRRow3037 MemRRow3038 1000.000000
R23038 MemRRow3038 MemRRow3039 1000.000000
R23039 MemRRow3039 MemRRow3040 1000.000000
R23040 MemRRow3040 MemRRow3041 1000.000000
R23041 MemRRow3041 MemRRow3042 1000.000000
R23042 MemRRow3042 MemRRow3043 1000.000000
R23043 MemRRow3043 MemRRow3044 1000.000000
R23044 MemRRow3044 MemRRow3045 1000.000000
R23045 MemRRow3045 MemRRow3046 1000.000000
R23046 MemRRow3046 MemRRow3047 1000.000000
R23047 MemRRow3047 MemRRow3048 1000.000000
R23048 MemRRow3048 MemRRow3049 1000.000000
R23049 MemRRow3049 MemRRow3050 1000.000000
R23050 MemRRow3050 MemRRow3051 1000.000000
R2311 MemRRow311 MemRRow312 1000.000000
R2312 MemRRow312 MemRRow313 1000.000000
R2313 MemRRow313 MemRRow314 1000.000000
R2314 MemRRow314 MemRRow315 1000.000000
R2315 MemRRow315 MemRRow316 1000.000000
R2316 MemRRow316 MemRRow317 1000.000000
R2317 MemRRow317 MemRRow318 1000.000000
R2318 MemRRow318 MemRRow319 1000.000000
R2319 MemRRow319 MemRRow3110 1000.000000
R23110 MemRRow3110 MemRRow3111 1000.000000
R23111 MemRRow3111 MemRRow3112 1000.000000
R23112 MemRRow3112 MemRRow3113 1000.000000
R23113 MemRRow3113 MemRRow3114 1000.000000
R23114 MemRRow3114 MemRRow3115 1000.000000
R23115 MemRRow3115 MemRRow3116 1000.000000
R23116 MemRRow3116 MemRRow3117 1000.000000
R23117 MemRRow3117 MemRRow3118 1000.000000
R23118 MemRRow3118 MemRRow3119 1000.000000
R23119 MemRRow3119 MemRRow3120 1000.000000
R23120 MemRRow3120 MemRRow3121 1000.000000
R23121 MemRRow3121 MemRRow3122 1000.000000
R23122 MemRRow3122 MemRRow3123 1000.000000
R23123 MemRRow3123 MemRRow3124 1000.000000
R23124 MemRRow3124 MemRRow3125 1000.000000
R23125 MemRRow3125 MemRRow3126 1000.000000
R23126 MemRRow3126 MemRRow3127 1000.000000
R23127 MemRRow3127 MemRRow3128 1000.000000
R23128 MemRRow3128 MemRRow3129 1000.000000
R23129 MemRRow3129 MemRRow3130 1000.000000
R23130 MemRRow3130 MemRRow3131 1000.000000
R23131 MemRRow3131 MemRRow3132 1000.000000
R23132 MemRRow3132 MemRRow3133 1000.000000
R23133 MemRRow3133 MemRRow3134 1000.000000
R23134 MemRRow3134 MemRRow3135 1000.000000
R23135 MemRRow3135 MemRRow3136 1000.000000
R23136 MemRRow3136 MemRRow3137 1000.000000
R23137 MemRRow3137 MemRRow3138 1000.000000
R23138 MemRRow3138 MemRRow3139 1000.000000
R23139 MemRRow3139 MemRRow3140 1000.000000
R23140 MemRRow3140 MemRRow3141 1000.000000
R23141 MemRRow3141 MemRRow3142 1000.000000
R23142 MemRRow3142 MemRRow3143 1000.000000
R23143 MemRRow3143 MemRRow3144 1000.000000
R23144 MemRRow3144 MemRRow3145 1000.000000
R23145 MemRRow3145 MemRRow3146 1000.000000
R23146 MemRRow3146 MemRRow3147 1000.000000
R23147 MemRRow3147 MemRRow3148 1000.000000
R23148 MemRRow3148 MemRRow3149 1000.000000
R23149 MemRRow3149 MemRRow3150 1000.000000
R23150 MemRRow3150 MemRRow3151 1000.000000
R2321 MemRRow321 MemRRow322 1000.000000
R2322 MemRRow322 MemRRow323 1000.000000
R2323 MemRRow323 MemRRow324 1000.000000
R2324 MemRRow324 MemRRow325 1000.000000
R2325 MemRRow325 MemRRow326 1000.000000
R2326 MemRRow326 MemRRow327 1000.000000
R2327 MemRRow327 MemRRow328 1000.000000
R2328 MemRRow328 MemRRow329 1000.000000
R2329 MemRRow329 MemRRow3210 1000.000000
R23210 MemRRow3210 MemRRow3211 1000.000000
R23211 MemRRow3211 MemRRow3212 1000.000000
R23212 MemRRow3212 MemRRow3213 1000.000000
R23213 MemRRow3213 MemRRow3214 1000.000000
R23214 MemRRow3214 MemRRow3215 1000.000000
R23215 MemRRow3215 MemRRow3216 1000.000000
R23216 MemRRow3216 MemRRow3217 1000.000000
R23217 MemRRow3217 MemRRow3218 1000.000000
R23218 MemRRow3218 MemRRow3219 1000.000000
R23219 MemRRow3219 MemRRow3220 1000.000000
R23220 MemRRow3220 MemRRow3221 1000.000000
R23221 MemRRow3221 MemRRow3222 1000.000000
R23222 MemRRow3222 MemRRow3223 1000.000000
R23223 MemRRow3223 MemRRow3224 1000.000000
R23224 MemRRow3224 MemRRow3225 1000.000000
R23225 MemRRow3225 MemRRow3226 1000.000000
R23226 MemRRow3226 MemRRow3227 1000.000000
R23227 MemRRow3227 MemRRow3228 1000.000000
R23228 MemRRow3228 MemRRow3229 1000.000000
R23229 MemRRow3229 MemRRow3230 1000.000000
R23230 MemRRow3230 MemRRow3231 1000.000000
R23231 MemRRow3231 MemRRow3232 1000.000000
R23232 MemRRow3232 MemRRow3233 1000.000000
R23233 MemRRow3233 MemRRow3234 1000.000000
R23234 MemRRow3234 MemRRow3235 1000.000000
R23235 MemRRow3235 MemRRow3236 1000.000000
R23236 MemRRow3236 MemRRow3237 1000.000000
R23237 MemRRow3237 MemRRow3238 1000.000000
R23238 MemRRow3238 MemRRow3239 1000.000000
R23239 MemRRow3239 MemRRow3240 1000.000000
R23240 MemRRow3240 MemRRow3241 1000.000000
R23241 MemRRow3241 MemRRow3242 1000.000000
R23242 MemRRow3242 MemRRow3243 1000.000000
R23243 MemRRow3243 MemRRow3244 1000.000000
R23244 MemRRow3244 MemRRow3245 1000.000000
R23245 MemRRow3245 MemRRow3246 1000.000000
R23246 MemRRow3246 MemRRow3247 1000.000000
R23247 MemRRow3247 MemRRow3248 1000.000000
R23248 MemRRow3248 MemRRow3249 1000.000000
R23249 MemRRow3249 MemRRow3250 1000.000000
R23250 MemRRow3250 MemRRow3251 1000.000000
R2331 MemRRow331 MemRRow332 1000.000000
R2332 MemRRow332 MemRRow333 1000.000000
R2333 MemRRow333 MemRRow334 1000.000000
R2334 MemRRow334 MemRRow335 1000.000000
R2335 MemRRow335 MemRRow336 1000.000000
R2336 MemRRow336 MemRRow337 1000.000000
R2337 MemRRow337 MemRRow338 1000.000000
R2338 MemRRow338 MemRRow339 1000.000000
R2339 MemRRow339 MemRRow3310 1000.000000
R23310 MemRRow3310 MemRRow3311 1000.000000
R23311 MemRRow3311 MemRRow3312 1000.000000
R23312 MemRRow3312 MemRRow3313 1000.000000
R23313 MemRRow3313 MemRRow3314 1000.000000
R23314 MemRRow3314 MemRRow3315 1000.000000
R23315 MemRRow3315 MemRRow3316 1000.000000
R23316 MemRRow3316 MemRRow3317 1000.000000
R23317 MemRRow3317 MemRRow3318 1000.000000
R23318 MemRRow3318 MemRRow3319 1000.000000
R23319 MemRRow3319 MemRRow3320 1000.000000
R23320 MemRRow3320 MemRRow3321 1000.000000
R23321 MemRRow3321 MemRRow3322 1000.000000
R23322 MemRRow3322 MemRRow3323 1000.000000
R23323 MemRRow3323 MemRRow3324 1000.000000
R23324 MemRRow3324 MemRRow3325 1000.000000
R23325 MemRRow3325 MemRRow3326 1000.000000
R23326 MemRRow3326 MemRRow3327 1000.000000
R23327 MemRRow3327 MemRRow3328 1000.000000
R23328 MemRRow3328 MemRRow3329 1000.000000
R23329 MemRRow3329 MemRRow3330 1000.000000
R23330 MemRRow3330 MemRRow3331 1000.000000
R23331 MemRRow3331 MemRRow3332 1000.000000
R23332 MemRRow3332 MemRRow3333 1000.000000
R23333 MemRRow3333 MemRRow3334 1000.000000
R23334 MemRRow3334 MemRRow3335 1000.000000
R23335 MemRRow3335 MemRRow3336 1000.000000
R23336 MemRRow3336 MemRRow3337 1000.000000
R23337 MemRRow3337 MemRRow3338 1000.000000
R23338 MemRRow3338 MemRRow3339 1000.000000
R23339 MemRRow3339 MemRRow3340 1000.000000
R23340 MemRRow3340 MemRRow3341 1000.000000
R23341 MemRRow3341 MemRRow3342 1000.000000
R23342 MemRRow3342 MemRRow3343 1000.000000
R23343 MemRRow3343 MemRRow3344 1000.000000
R23344 MemRRow3344 MemRRow3345 1000.000000
R23345 MemRRow3345 MemRRow3346 1000.000000
R23346 MemRRow3346 MemRRow3347 1000.000000
R23347 MemRRow3347 MemRRow3348 1000.000000
R23348 MemRRow3348 MemRRow3349 1000.000000
R23349 MemRRow3349 MemRRow3350 1000.000000
R23350 MemRRow3350 MemRRow3351 1000.000000
R2341 MemRRow341 MemRRow342 1000.000000
R2342 MemRRow342 MemRRow343 1000.000000
R2343 MemRRow343 MemRRow344 1000.000000
R2344 MemRRow344 MemRRow345 1000.000000
R2345 MemRRow345 MemRRow346 1000.000000
R2346 MemRRow346 MemRRow347 1000.000000
R2347 MemRRow347 MemRRow348 1000.000000
R2348 MemRRow348 MemRRow349 1000.000000
R2349 MemRRow349 MemRRow3410 1000.000000
R23410 MemRRow3410 MemRRow3411 1000.000000
R23411 MemRRow3411 MemRRow3412 1000.000000
R23412 MemRRow3412 MemRRow3413 1000.000000
R23413 MemRRow3413 MemRRow3414 1000.000000
R23414 MemRRow3414 MemRRow3415 1000.000000
R23415 MemRRow3415 MemRRow3416 1000.000000
R23416 MemRRow3416 MemRRow3417 1000.000000
R23417 MemRRow3417 MemRRow3418 1000.000000
R23418 MemRRow3418 MemRRow3419 1000.000000
R23419 MemRRow3419 MemRRow3420 1000.000000
R23420 MemRRow3420 MemRRow3421 1000.000000
R23421 MemRRow3421 MemRRow3422 1000.000000
R23422 MemRRow3422 MemRRow3423 1000.000000
R23423 MemRRow3423 MemRRow3424 1000.000000
R23424 MemRRow3424 MemRRow3425 1000.000000
R23425 MemRRow3425 MemRRow3426 1000.000000
R23426 MemRRow3426 MemRRow3427 1000.000000
R23427 MemRRow3427 MemRRow3428 1000.000000
R23428 MemRRow3428 MemRRow3429 1000.000000
R23429 MemRRow3429 MemRRow3430 1000.000000
R23430 MemRRow3430 MemRRow3431 1000.000000
R23431 MemRRow3431 MemRRow3432 1000.000000
R23432 MemRRow3432 MemRRow3433 1000.000000
R23433 MemRRow3433 MemRRow3434 1000.000000
R23434 MemRRow3434 MemRRow3435 1000.000000
R23435 MemRRow3435 MemRRow3436 1000.000000
R23436 MemRRow3436 MemRRow3437 1000.000000
R23437 MemRRow3437 MemRRow3438 1000.000000
R23438 MemRRow3438 MemRRow3439 1000.000000
R23439 MemRRow3439 MemRRow3440 1000.000000
R23440 MemRRow3440 MemRRow3441 1000.000000
R23441 MemRRow3441 MemRRow3442 1000.000000
R23442 MemRRow3442 MemRRow3443 1000.000000
R23443 MemRRow3443 MemRRow3444 1000.000000
R23444 MemRRow3444 MemRRow3445 1000.000000
R23445 MemRRow3445 MemRRow3446 1000.000000
R23446 MemRRow3446 MemRRow3447 1000.000000
R23447 MemRRow3447 MemRRow3448 1000.000000
R23448 MemRRow3448 MemRRow3449 1000.000000
R23449 MemRRow3449 MemRRow3450 1000.000000
R23450 MemRRow3450 MemRRow3451 1000.000000
R2351 MemRRow351 MemRRow352 1000.000000
R2352 MemRRow352 MemRRow353 1000.000000
R2353 MemRRow353 MemRRow354 1000.000000
R2354 MemRRow354 MemRRow355 1000.000000
R2355 MemRRow355 MemRRow356 1000.000000
R2356 MemRRow356 MemRRow357 1000.000000
R2357 MemRRow357 MemRRow358 1000.000000
R2358 MemRRow358 MemRRow359 1000.000000
R2359 MemRRow359 MemRRow3510 1000.000000
R23510 MemRRow3510 MemRRow3511 1000.000000
R23511 MemRRow3511 MemRRow3512 1000.000000
R23512 MemRRow3512 MemRRow3513 1000.000000
R23513 MemRRow3513 MemRRow3514 1000.000000
R23514 MemRRow3514 MemRRow3515 1000.000000
R23515 MemRRow3515 MemRRow3516 1000.000000
R23516 MemRRow3516 MemRRow3517 1000.000000
R23517 MemRRow3517 MemRRow3518 1000.000000
R23518 MemRRow3518 MemRRow3519 1000.000000
R23519 MemRRow3519 MemRRow3520 1000.000000
R23520 MemRRow3520 MemRRow3521 1000.000000
R23521 MemRRow3521 MemRRow3522 1000.000000
R23522 MemRRow3522 MemRRow3523 1000.000000
R23523 MemRRow3523 MemRRow3524 1000.000000
R23524 MemRRow3524 MemRRow3525 1000.000000
R23525 MemRRow3525 MemRRow3526 1000.000000
R23526 MemRRow3526 MemRRow3527 1000.000000
R23527 MemRRow3527 MemRRow3528 1000.000000
R23528 MemRRow3528 MemRRow3529 1000.000000
R23529 MemRRow3529 MemRRow3530 1000.000000
R23530 MemRRow3530 MemRRow3531 1000.000000
R23531 MemRRow3531 MemRRow3532 1000.000000
R23532 MemRRow3532 MemRRow3533 1000.000000
R23533 MemRRow3533 MemRRow3534 1000.000000
R23534 MemRRow3534 MemRRow3535 1000.000000
R23535 MemRRow3535 MemRRow3536 1000.000000
R23536 MemRRow3536 MemRRow3537 1000.000000
R23537 MemRRow3537 MemRRow3538 1000.000000
R23538 MemRRow3538 MemRRow3539 1000.000000
R23539 MemRRow3539 MemRRow3540 1000.000000
R23540 MemRRow3540 MemRRow3541 1000.000000
R23541 MemRRow3541 MemRRow3542 1000.000000
R23542 MemRRow3542 MemRRow3543 1000.000000
R23543 MemRRow3543 MemRRow3544 1000.000000
R23544 MemRRow3544 MemRRow3545 1000.000000
R23545 MemRRow3545 MemRRow3546 1000.000000
R23546 MemRRow3546 MemRRow3547 1000.000000
R23547 MemRRow3547 MemRRow3548 1000.000000
R23548 MemRRow3548 MemRRow3549 1000.000000
R23549 MemRRow3549 MemRRow3550 1000.000000
R23550 MemRRow3550 MemRRow3551 1000.000000
R2361 MemRRow361 MemRRow362 1000.000000
R2362 MemRRow362 MemRRow363 1000.000000
R2363 MemRRow363 MemRRow364 1000.000000
R2364 MemRRow364 MemRRow365 1000.000000
R2365 MemRRow365 MemRRow366 1000.000000
R2366 MemRRow366 MemRRow367 1000.000000
R2367 MemRRow367 MemRRow368 1000.000000
R2368 MemRRow368 MemRRow369 1000.000000
R2369 MemRRow369 MemRRow3610 1000.000000
R23610 MemRRow3610 MemRRow3611 1000.000000
R23611 MemRRow3611 MemRRow3612 1000.000000
R23612 MemRRow3612 MemRRow3613 1000.000000
R23613 MemRRow3613 MemRRow3614 1000.000000
R23614 MemRRow3614 MemRRow3615 1000.000000
R23615 MemRRow3615 MemRRow3616 1000.000000
R23616 MemRRow3616 MemRRow3617 1000.000000
R23617 MemRRow3617 MemRRow3618 1000.000000
R23618 MemRRow3618 MemRRow3619 1000.000000
R23619 MemRRow3619 MemRRow3620 1000.000000
R23620 MemRRow3620 MemRRow3621 1000.000000
R23621 MemRRow3621 MemRRow3622 1000.000000
R23622 MemRRow3622 MemRRow3623 1000.000000
R23623 MemRRow3623 MemRRow3624 1000.000000
R23624 MemRRow3624 MemRRow3625 1000.000000
R23625 MemRRow3625 MemRRow3626 1000.000000
R23626 MemRRow3626 MemRRow3627 1000.000000
R23627 MemRRow3627 MemRRow3628 1000.000000
R23628 MemRRow3628 MemRRow3629 1000.000000
R23629 MemRRow3629 MemRRow3630 1000.000000
R23630 MemRRow3630 MemRRow3631 1000.000000
R23631 MemRRow3631 MemRRow3632 1000.000000
R23632 MemRRow3632 MemRRow3633 1000.000000
R23633 MemRRow3633 MemRRow3634 1000.000000
R23634 MemRRow3634 MemRRow3635 1000.000000
R23635 MemRRow3635 MemRRow3636 1000.000000
R23636 MemRRow3636 MemRRow3637 1000.000000
R23637 MemRRow3637 MemRRow3638 1000.000000
R23638 MemRRow3638 MemRRow3639 1000.000000
R23639 MemRRow3639 MemRRow3640 1000.000000
R23640 MemRRow3640 MemRRow3641 1000.000000
R23641 MemRRow3641 MemRRow3642 1000.000000
R23642 MemRRow3642 MemRRow3643 1000.000000
R23643 MemRRow3643 MemRRow3644 1000.000000
R23644 MemRRow3644 MemRRow3645 1000.000000
R23645 MemRRow3645 MemRRow3646 1000.000000
R23646 MemRRow3646 MemRRow3647 1000.000000
R23647 MemRRow3647 MemRRow3648 1000.000000
R23648 MemRRow3648 MemRRow3649 1000.000000
R23649 MemRRow3649 MemRRow3650 1000.000000
R23650 MemRRow3650 MemRRow3651 1000.000000
R2371 MemRRow371 MemRRow372 1000.000000
R2372 MemRRow372 MemRRow373 1000.000000
R2373 MemRRow373 MemRRow374 1000.000000
R2374 MemRRow374 MemRRow375 1000.000000
R2375 MemRRow375 MemRRow376 1000.000000
R2376 MemRRow376 MemRRow377 1000.000000
R2377 MemRRow377 MemRRow378 1000.000000
R2378 MemRRow378 MemRRow379 1000.000000
R2379 MemRRow379 MemRRow3710 1000.000000
R23710 MemRRow3710 MemRRow3711 1000.000000
R23711 MemRRow3711 MemRRow3712 1000.000000
R23712 MemRRow3712 MemRRow3713 1000.000000
R23713 MemRRow3713 MemRRow3714 1000.000000
R23714 MemRRow3714 MemRRow3715 1000.000000
R23715 MemRRow3715 MemRRow3716 1000.000000
R23716 MemRRow3716 MemRRow3717 1000.000000
R23717 MemRRow3717 MemRRow3718 1000.000000
R23718 MemRRow3718 MemRRow3719 1000.000000
R23719 MemRRow3719 MemRRow3720 1000.000000
R23720 MemRRow3720 MemRRow3721 1000.000000
R23721 MemRRow3721 MemRRow3722 1000.000000
R23722 MemRRow3722 MemRRow3723 1000.000000
R23723 MemRRow3723 MemRRow3724 1000.000000
R23724 MemRRow3724 MemRRow3725 1000.000000
R23725 MemRRow3725 MemRRow3726 1000.000000
R23726 MemRRow3726 MemRRow3727 1000.000000
R23727 MemRRow3727 MemRRow3728 1000.000000
R23728 MemRRow3728 MemRRow3729 1000.000000
R23729 MemRRow3729 MemRRow3730 1000.000000
R23730 MemRRow3730 MemRRow3731 1000.000000
R23731 MemRRow3731 MemRRow3732 1000.000000
R23732 MemRRow3732 MemRRow3733 1000.000000
R23733 MemRRow3733 MemRRow3734 1000.000000
R23734 MemRRow3734 MemRRow3735 1000.000000
R23735 MemRRow3735 MemRRow3736 1000.000000
R23736 MemRRow3736 MemRRow3737 1000.000000
R23737 MemRRow3737 MemRRow3738 1000.000000
R23738 MemRRow3738 MemRRow3739 1000.000000
R23739 MemRRow3739 MemRRow3740 1000.000000
R23740 MemRRow3740 MemRRow3741 1000.000000
R23741 MemRRow3741 MemRRow3742 1000.000000
R23742 MemRRow3742 MemRRow3743 1000.000000
R23743 MemRRow3743 MemRRow3744 1000.000000
R23744 MemRRow3744 MemRRow3745 1000.000000
R23745 MemRRow3745 MemRRow3746 1000.000000
R23746 MemRRow3746 MemRRow3747 1000.000000
R23747 MemRRow3747 MemRRow3748 1000.000000
R23748 MemRRow3748 MemRRow3749 1000.000000
R23749 MemRRow3749 MemRRow3750 1000.000000
R23750 MemRRow3750 MemRRow3751 1000.000000
R2381 MemRRow381 MemRRow382 1000.000000
R2382 MemRRow382 MemRRow383 1000.000000
R2383 MemRRow383 MemRRow384 1000.000000
R2384 MemRRow384 MemRRow385 1000.000000
R2385 MemRRow385 MemRRow386 1000.000000
R2386 MemRRow386 MemRRow387 1000.000000
R2387 MemRRow387 MemRRow388 1000.000000
R2388 MemRRow388 MemRRow389 1000.000000
R2389 MemRRow389 MemRRow3810 1000.000000
R23810 MemRRow3810 MemRRow3811 1000.000000
R23811 MemRRow3811 MemRRow3812 1000.000000
R23812 MemRRow3812 MemRRow3813 1000.000000
R23813 MemRRow3813 MemRRow3814 1000.000000
R23814 MemRRow3814 MemRRow3815 1000.000000
R23815 MemRRow3815 MemRRow3816 1000.000000
R23816 MemRRow3816 MemRRow3817 1000.000000
R23817 MemRRow3817 MemRRow3818 1000.000000
R23818 MemRRow3818 MemRRow3819 1000.000000
R23819 MemRRow3819 MemRRow3820 1000.000000
R23820 MemRRow3820 MemRRow3821 1000.000000
R23821 MemRRow3821 MemRRow3822 1000.000000
R23822 MemRRow3822 MemRRow3823 1000.000000
R23823 MemRRow3823 MemRRow3824 1000.000000
R23824 MemRRow3824 MemRRow3825 1000.000000
R23825 MemRRow3825 MemRRow3826 1000.000000
R23826 MemRRow3826 MemRRow3827 1000.000000
R23827 MemRRow3827 MemRRow3828 1000.000000
R23828 MemRRow3828 MemRRow3829 1000.000000
R23829 MemRRow3829 MemRRow3830 1000.000000
R23830 MemRRow3830 MemRRow3831 1000.000000
R23831 MemRRow3831 MemRRow3832 1000.000000
R23832 MemRRow3832 MemRRow3833 1000.000000
R23833 MemRRow3833 MemRRow3834 1000.000000
R23834 MemRRow3834 MemRRow3835 1000.000000
R23835 MemRRow3835 MemRRow3836 1000.000000
R23836 MemRRow3836 MemRRow3837 1000.000000
R23837 MemRRow3837 MemRRow3838 1000.000000
R23838 MemRRow3838 MemRRow3839 1000.000000
R23839 MemRRow3839 MemRRow3840 1000.000000
R23840 MemRRow3840 MemRRow3841 1000.000000
R23841 MemRRow3841 MemRRow3842 1000.000000
R23842 MemRRow3842 MemRRow3843 1000.000000
R23843 MemRRow3843 MemRRow3844 1000.000000
R23844 MemRRow3844 MemRRow3845 1000.000000
R23845 MemRRow3845 MemRRow3846 1000.000000
R23846 MemRRow3846 MemRRow3847 1000.000000
R23847 MemRRow3847 MemRRow3848 1000.000000
R23848 MemRRow3848 MemRRow3849 1000.000000
R23849 MemRRow3849 MemRRow3850 1000.000000
R23850 MemRRow3850 MemRRow3851 1000.000000
R2391 MemRRow391 MemRRow392 1000.000000
R2392 MemRRow392 MemRRow393 1000.000000
R2393 MemRRow393 MemRRow394 1000.000000
R2394 MemRRow394 MemRRow395 1000.000000
R2395 MemRRow395 MemRRow396 1000.000000
R2396 MemRRow396 MemRRow397 1000.000000
R2397 MemRRow397 MemRRow398 1000.000000
R2398 MemRRow398 MemRRow399 1000.000000
R2399 MemRRow399 MemRRow3910 1000.000000
R23910 MemRRow3910 MemRRow3911 1000.000000
R23911 MemRRow3911 MemRRow3912 1000.000000
R23912 MemRRow3912 MemRRow3913 1000.000000
R23913 MemRRow3913 MemRRow3914 1000.000000
R23914 MemRRow3914 MemRRow3915 1000.000000
R23915 MemRRow3915 MemRRow3916 1000.000000
R23916 MemRRow3916 MemRRow3917 1000.000000
R23917 MemRRow3917 MemRRow3918 1000.000000
R23918 MemRRow3918 MemRRow3919 1000.000000
R23919 MemRRow3919 MemRRow3920 1000.000000
R23920 MemRRow3920 MemRRow3921 1000.000000
R23921 MemRRow3921 MemRRow3922 1000.000000
R23922 MemRRow3922 MemRRow3923 1000.000000
R23923 MemRRow3923 MemRRow3924 1000.000000
R23924 MemRRow3924 MemRRow3925 1000.000000
R23925 MemRRow3925 MemRRow3926 1000.000000
R23926 MemRRow3926 MemRRow3927 1000.000000
R23927 MemRRow3927 MemRRow3928 1000.000000
R23928 MemRRow3928 MemRRow3929 1000.000000
R23929 MemRRow3929 MemRRow3930 1000.000000
R23930 MemRRow3930 MemRRow3931 1000.000000
R23931 MemRRow3931 MemRRow3932 1000.000000
R23932 MemRRow3932 MemRRow3933 1000.000000
R23933 MemRRow3933 MemRRow3934 1000.000000
R23934 MemRRow3934 MemRRow3935 1000.000000
R23935 MemRRow3935 MemRRow3936 1000.000000
R23936 MemRRow3936 MemRRow3937 1000.000000
R23937 MemRRow3937 MemRRow3938 1000.000000
R23938 MemRRow3938 MemRRow3939 1000.000000
R23939 MemRRow3939 MemRRow3940 1000.000000
R23940 MemRRow3940 MemRRow3941 1000.000000
R23941 MemRRow3941 MemRRow3942 1000.000000
R23942 MemRRow3942 MemRRow3943 1000.000000
R23943 MemRRow3943 MemRRow3944 1000.000000
R23944 MemRRow3944 MemRRow3945 1000.000000
R23945 MemRRow3945 MemRRow3946 1000.000000
R23946 MemRRow3946 MemRRow3947 1000.000000
R23947 MemRRow3947 MemRRow3948 1000.000000
R23948 MemRRow3948 MemRRow3949 1000.000000
R23949 MemRRow3949 MemRRow3950 1000.000000
R23950 MemRRow3950 MemRRow3951 1000.000000
R2401 MemRRow401 MemRRow402 1000.000000
R2402 MemRRow402 MemRRow403 1000.000000
R2403 MemRRow403 MemRRow404 1000.000000
R2404 MemRRow404 MemRRow405 1000.000000
R2405 MemRRow405 MemRRow406 1000.000000
R2406 MemRRow406 MemRRow407 1000.000000
R2407 MemRRow407 MemRRow408 1000.000000
R2408 MemRRow408 MemRRow409 1000.000000
R2409 MemRRow409 MemRRow4010 1000.000000
R24010 MemRRow4010 MemRRow4011 1000.000000
R24011 MemRRow4011 MemRRow4012 1000.000000
R24012 MemRRow4012 MemRRow4013 1000.000000
R24013 MemRRow4013 MemRRow4014 1000.000000
R24014 MemRRow4014 MemRRow4015 1000.000000
R24015 MemRRow4015 MemRRow4016 1000.000000
R24016 MemRRow4016 MemRRow4017 1000.000000
R24017 MemRRow4017 MemRRow4018 1000.000000
R24018 MemRRow4018 MemRRow4019 1000.000000
R24019 MemRRow4019 MemRRow4020 1000.000000
R24020 MemRRow4020 MemRRow4021 1000.000000
R24021 MemRRow4021 MemRRow4022 1000.000000
R24022 MemRRow4022 MemRRow4023 1000.000000
R24023 MemRRow4023 MemRRow4024 1000.000000
R24024 MemRRow4024 MemRRow4025 1000.000000
R24025 MemRRow4025 MemRRow4026 1000.000000
R24026 MemRRow4026 MemRRow4027 1000.000000
R24027 MemRRow4027 MemRRow4028 1000.000000
R24028 MemRRow4028 MemRRow4029 1000.000000
R24029 MemRRow4029 MemRRow4030 1000.000000
R24030 MemRRow4030 MemRRow4031 1000.000000
R24031 MemRRow4031 MemRRow4032 1000.000000
R24032 MemRRow4032 MemRRow4033 1000.000000
R24033 MemRRow4033 MemRRow4034 1000.000000
R24034 MemRRow4034 MemRRow4035 1000.000000
R24035 MemRRow4035 MemRRow4036 1000.000000
R24036 MemRRow4036 MemRRow4037 1000.000000
R24037 MemRRow4037 MemRRow4038 1000.000000
R24038 MemRRow4038 MemRRow4039 1000.000000
R24039 MemRRow4039 MemRRow4040 1000.000000
R24040 MemRRow4040 MemRRow4041 1000.000000
R24041 MemRRow4041 MemRRow4042 1000.000000
R24042 MemRRow4042 MemRRow4043 1000.000000
R24043 MemRRow4043 MemRRow4044 1000.000000
R24044 MemRRow4044 MemRRow4045 1000.000000
R24045 MemRRow4045 MemRRow4046 1000.000000
R24046 MemRRow4046 MemRRow4047 1000.000000
R24047 MemRRow4047 MemRRow4048 1000.000000
R24048 MemRRow4048 MemRRow4049 1000.000000
R24049 MemRRow4049 MemRRow4050 1000.000000
R24050 MemRRow4050 MemRRow4051 1000.000000
R2411 MemRRow411 MemRRow412 1000.000000
R2412 MemRRow412 MemRRow413 1000.000000
R2413 MemRRow413 MemRRow414 1000.000000
R2414 MemRRow414 MemRRow415 1000.000000
R2415 MemRRow415 MemRRow416 1000.000000
R2416 MemRRow416 MemRRow417 1000.000000
R2417 MemRRow417 MemRRow418 1000.000000
R2418 MemRRow418 MemRRow419 1000.000000
R2419 MemRRow419 MemRRow4110 1000.000000
R24110 MemRRow4110 MemRRow4111 1000.000000
R24111 MemRRow4111 MemRRow4112 1000.000000
R24112 MemRRow4112 MemRRow4113 1000.000000
R24113 MemRRow4113 MemRRow4114 1000.000000
R24114 MemRRow4114 MemRRow4115 1000.000000
R24115 MemRRow4115 MemRRow4116 1000.000000
R24116 MemRRow4116 MemRRow4117 1000.000000
R24117 MemRRow4117 MemRRow4118 1000.000000
R24118 MemRRow4118 MemRRow4119 1000.000000
R24119 MemRRow4119 MemRRow4120 1000.000000
R24120 MemRRow4120 MemRRow4121 1000.000000
R24121 MemRRow4121 MemRRow4122 1000.000000
R24122 MemRRow4122 MemRRow4123 1000.000000
R24123 MemRRow4123 MemRRow4124 1000.000000
R24124 MemRRow4124 MemRRow4125 1000.000000
R24125 MemRRow4125 MemRRow4126 1000.000000
R24126 MemRRow4126 MemRRow4127 1000.000000
R24127 MemRRow4127 MemRRow4128 1000.000000
R24128 MemRRow4128 MemRRow4129 1000.000000
R24129 MemRRow4129 MemRRow4130 1000.000000
R24130 MemRRow4130 MemRRow4131 1000.000000
R24131 MemRRow4131 MemRRow4132 1000.000000
R24132 MemRRow4132 MemRRow4133 1000.000000
R24133 MemRRow4133 MemRRow4134 1000.000000
R24134 MemRRow4134 MemRRow4135 1000.000000
R24135 MemRRow4135 MemRRow4136 1000.000000
R24136 MemRRow4136 MemRRow4137 1000.000000
R24137 MemRRow4137 MemRRow4138 1000.000000
R24138 MemRRow4138 MemRRow4139 1000.000000
R24139 MemRRow4139 MemRRow4140 1000.000000
R24140 MemRRow4140 MemRRow4141 1000.000000
R24141 MemRRow4141 MemRRow4142 1000.000000
R24142 MemRRow4142 MemRRow4143 1000.000000
R24143 MemRRow4143 MemRRow4144 1000.000000
R24144 MemRRow4144 MemRRow4145 1000.000000
R24145 MemRRow4145 MemRRow4146 1000.000000
R24146 MemRRow4146 MemRRow4147 1000.000000
R24147 MemRRow4147 MemRRow4148 1000.000000
R24148 MemRRow4148 MemRRow4149 1000.000000
R24149 MemRRow4149 MemRRow4150 1000.000000
R24150 MemRRow4150 MemRRow4151 1000.000000
R2421 MemRRow421 MemRRow422 1000.000000
R2422 MemRRow422 MemRRow423 1000.000000
R2423 MemRRow423 MemRRow424 1000.000000
R2424 MemRRow424 MemRRow425 1000.000000
R2425 MemRRow425 MemRRow426 1000.000000
R2426 MemRRow426 MemRRow427 1000.000000
R2427 MemRRow427 MemRRow428 1000.000000
R2428 MemRRow428 MemRRow429 1000.000000
R2429 MemRRow429 MemRRow4210 1000.000000
R24210 MemRRow4210 MemRRow4211 1000.000000
R24211 MemRRow4211 MemRRow4212 1000.000000
R24212 MemRRow4212 MemRRow4213 1000.000000
R24213 MemRRow4213 MemRRow4214 1000.000000
R24214 MemRRow4214 MemRRow4215 1000.000000
R24215 MemRRow4215 MemRRow4216 1000.000000
R24216 MemRRow4216 MemRRow4217 1000.000000
R24217 MemRRow4217 MemRRow4218 1000.000000
R24218 MemRRow4218 MemRRow4219 1000.000000
R24219 MemRRow4219 MemRRow4220 1000.000000
R24220 MemRRow4220 MemRRow4221 1000.000000
R24221 MemRRow4221 MemRRow4222 1000.000000
R24222 MemRRow4222 MemRRow4223 1000.000000
R24223 MemRRow4223 MemRRow4224 1000.000000
R24224 MemRRow4224 MemRRow4225 1000.000000
R24225 MemRRow4225 MemRRow4226 1000.000000
R24226 MemRRow4226 MemRRow4227 1000.000000
R24227 MemRRow4227 MemRRow4228 1000.000000
R24228 MemRRow4228 MemRRow4229 1000.000000
R24229 MemRRow4229 MemRRow4230 1000.000000
R24230 MemRRow4230 MemRRow4231 1000.000000
R24231 MemRRow4231 MemRRow4232 1000.000000
R24232 MemRRow4232 MemRRow4233 1000.000000
R24233 MemRRow4233 MemRRow4234 1000.000000
R24234 MemRRow4234 MemRRow4235 1000.000000
R24235 MemRRow4235 MemRRow4236 1000.000000
R24236 MemRRow4236 MemRRow4237 1000.000000
R24237 MemRRow4237 MemRRow4238 1000.000000
R24238 MemRRow4238 MemRRow4239 1000.000000
R24239 MemRRow4239 MemRRow4240 1000.000000
R24240 MemRRow4240 MemRRow4241 1000.000000
R24241 MemRRow4241 MemRRow4242 1000.000000
R24242 MemRRow4242 MemRRow4243 1000.000000
R24243 MemRRow4243 MemRRow4244 1000.000000
R24244 MemRRow4244 MemRRow4245 1000.000000
R24245 MemRRow4245 MemRRow4246 1000.000000
R24246 MemRRow4246 MemRRow4247 1000.000000
R24247 MemRRow4247 MemRRow4248 1000.000000
R24248 MemRRow4248 MemRRow4249 1000.000000
R24249 MemRRow4249 MemRRow4250 1000.000000
R24250 MemRRow4250 MemRRow4251 1000.000000
R2431 MemRRow431 MemRRow432 1000.000000
R2432 MemRRow432 MemRRow433 1000.000000
R2433 MemRRow433 MemRRow434 1000.000000
R2434 MemRRow434 MemRRow435 1000.000000
R2435 MemRRow435 MemRRow436 1000.000000
R2436 MemRRow436 MemRRow437 1000.000000
R2437 MemRRow437 MemRRow438 1000.000000
R2438 MemRRow438 MemRRow439 1000.000000
R2439 MemRRow439 MemRRow4310 1000.000000
R24310 MemRRow4310 MemRRow4311 1000.000000
R24311 MemRRow4311 MemRRow4312 1000.000000
R24312 MemRRow4312 MemRRow4313 1000.000000
R24313 MemRRow4313 MemRRow4314 1000.000000
R24314 MemRRow4314 MemRRow4315 1000.000000
R24315 MemRRow4315 MemRRow4316 1000.000000
R24316 MemRRow4316 MemRRow4317 1000.000000
R24317 MemRRow4317 MemRRow4318 1000.000000
R24318 MemRRow4318 MemRRow4319 1000.000000
R24319 MemRRow4319 MemRRow4320 1000.000000
R24320 MemRRow4320 MemRRow4321 1000.000000
R24321 MemRRow4321 MemRRow4322 1000.000000
R24322 MemRRow4322 MemRRow4323 1000.000000
R24323 MemRRow4323 MemRRow4324 1000.000000
R24324 MemRRow4324 MemRRow4325 1000.000000
R24325 MemRRow4325 MemRRow4326 1000.000000
R24326 MemRRow4326 MemRRow4327 1000.000000
R24327 MemRRow4327 MemRRow4328 1000.000000
R24328 MemRRow4328 MemRRow4329 1000.000000
R24329 MemRRow4329 MemRRow4330 1000.000000
R24330 MemRRow4330 MemRRow4331 1000.000000
R24331 MemRRow4331 MemRRow4332 1000.000000
R24332 MemRRow4332 MemRRow4333 1000.000000
R24333 MemRRow4333 MemRRow4334 1000.000000
R24334 MemRRow4334 MemRRow4335 1000.000000
R24335 MemRRow4335 MemRRow4336 1000.000000
R24336 MemRRow4336 MemRRow4337 1000.000000
R24337 MemRRow4337 MemRRow4338 1000.000000
R24338 MemRRow4338 MemRRow4339 1000.000000
R24339 MemRRow4339 MemRRow4340 1000.000000
R24340 MemRRow4340 MemRRow4341 1000.000000
R24341 MemRRow4341 MemRRow4342 1000.000000
R24342 MemRRow4342 MemRRow4343 1000.000000
R24343 MemRRow4343 MemRRow4344 1000.000000
R24344 MemRRow4344 MemRRow4345 1000.000000
R24345 MemRRow4345 MemRRow4346 1000.000000
R24346 MemRRow4346 MemRRow4347 1000.000000
R24347 MemRRow4347 MemRRow4348 1000.000000
R24348 MemRRow4348 MemRRow4349 1000.000000
R24349 MemRRow4349 MemRRow4350 1000.000000
R24350 MemRRow4350 MemRRow4351 1000.000000
R2441 MemRRow441 MemRRow442 1000.000000
R2442 MemRRow442 MemRRow443 1000.000000
R2443 MemRRow443 MemRRow444 1000.000000
R2444 MemRRow444 MemRRow445 1000.000000
R2445 MemRRow445 MemRRow446 1000.000000
R2446 MemRRow446 MemRRow447 1000.000000
R2447 MemRRow447 MemRRow448 1000.000000
R2448 MemRRow448 MemRRow449 1000.000000
R2449 MemRRow449 MemRRow4410 1000.000000
R24410 MemRRow4410 MemRRow4411 1000.000000
R24411 MemRRow4411 MemRRow4412 1000.000000
R24412 MemRRow4412 MemRRow4413 1000.000000
R24413 MemRRow4413 MemRRow4414 1000.000000
R24414 MemRRow4414 MemRRow4415 1000.000000
R24415 MemRRow4415 MemRRow4416 1000.000000
R24416 MemRRow4416 MemRRow4417 1000.000000
R24417 MemRRow4417 MemRRow4418 1000.000000
R24418 MemRRow4418 MemRRow4419 1000.000000
R24419 MemRRow4419 MemRRow4420 1000.000000
R24420 MemRRow4420 MemRRow4421 1000.000000
R24421 MemRRow4421 MemRRow4422 1000.000000
R24422 MemRRow4422 MemRRow4423 1000.000000
R24423 MemRRow4423 MemRRow4424 1000.000000
R24424 MemRRow4424 MemRRow4425 1000.000000
R24425 MemRRow4425 MemRRow4426 1000.000000
R24426 MemRRow4426 MemRRow4427 1000.000000
R24427 MemRRow4427 MemRRow4428 1000.000000
R24428 MemRRow4428 MemRRow4429 1000.000000
R24429 MemRRow4429 MemRRow4430 1000.000000
R24430 MemRRow4430 MemRRow4431 1000.000000
R24431 MemRRow4431 MemRRow4432 1000.000000
R24432 MemRRow4432 MemRRow4433 1000.000000
R24433 MemRRow4433 MemRRow4434 1000.000000
R24434 MemRRow4434 MemRRow4435 1000.000000
R24435 MemRRow4435 MemRRow4436 1000.000000
R24436 MemRRow4436 MemRRow4437 1000.000000
R24437 MemRRow4437 MemRRow4438 1000.000000
R24438 MemRRow4438 MemRRow4439 1000.000000
R24439 MemRRow4439 MemRRow4440 1000.000000
R24440 MemRRow4440 MemRRow4441 1000.000000
R24441 MemRRow4441 MemRRow4442 1000.000000
R24442 MemRRow4442 MemRRow4443 1000.000000
R24443 MemRRow4443 MemRRow4444 1000.000000
R24444 MemRRow4444 MemRRow4445 1000.000000
R24445 MemRRow4445 MemRRow4446 1000.000000
R24446 MemRRow4446 MemRRow4447 1000.000000
R24447 MemRRow4447 MemRRow4448 1000.000000
R24448 MemRRow4448 MemRRow4449 1000.000000
R24449 MemRRow4449 MemRRow4450 1000.000000
R24450 MemRRow4450 MemRRow4451 1000.000000
R2451 MemRRow451 MemRRow452 1000.000000
R2452 MemRRow452 MemRRow453 1000.000000
R2453 MemRRow453 MemRRow454 1000.000000
R2454 MemRRow454 MemRRow455 1000.000000
R2455 MemRRow455 MemRRow456 1000.000000
R2456 MemRRow456 MemRRow457 1000.000000
R2457 MemRRow457 MemRRow458 1000.000000
R2458 MemRRow458 MemRRow459 1000.000000
R2459 MemRRow459 MemRRow4510 1000.000000
R24510 MemRRow4510 MemRRow4511 1000.000000
R24511 MemRRow4511 MemRRow4512 1000.000000
R24512 MemRRow4512 MemRRow4513 1000.000000
R24513 MemRRow4513 MemRRow4514 1000.000000
R24514 MemRRow4514 MemRRow4515 1000.000000
R24515 MemRRow4515 MemRRow4516 1000.000000
R24516 MemRRow4516 MemRRow4517 1000.000000
R24517 MemRRow4517 MemRRow4518 1000.000000
R24518 MemRRow4518 MemRRow4519 1000.000000
R24519 MemRRow4519 MemRRow4520 1000.000000
R24520 MemRRow4520 MemRRow4521 1000.000000
R24521 MemRRow4521 MemRRow4522 1000.000000
R24522 MemRRow4522 MemRRow4523 1000.000000
R24523 MemRRow4523 MemRRow4524 1000.000000
R24524 MemRRow4524 MemRRow4525 1000.000000
R24525 MemRRow4525 MemRRow4526 1000.000000
R24526 MemRRow4526 MemRRow4527 1000.000000
R24527 MemRRow4527 MemRRow4528 1000.000000
R24528 MemRRow4528 MemRRow4529 1000.000000
R24529 MemRRow4529 MemRRow4530 1000.000000
R24530 MemRRow4530 MemRRow4531 1000.000000
R24531 MemRRow4531 MemRRow4532 1000.000000
R24532 MemRRow4532 MemRRow4533 1000.000000
R24533 MemRRow4533 MemRRow4534 1000.000000
R24534 MemRRow4534 MemRRow4535 1000.000000
R24535 MemRRow4535 MemRRow4536 1000.000000
R24536 MemRRow4536 MemRRow4537 1000.000000
R24537 MemRRow4537 MemRRow4538 1000.000000
R24538 MemRRow4538 MemRRow4539 1000.000000
R24539 MemRRow4539 MemRRow4540 1000.000000
R24540 MemRRow4540 MemRRow4541 1000.000000
R24541 MemRRow4541 MemRRow4542 1000.000000
R24542 MemRRow4542 MemRRow4543 1000.000000
R24543 MemRRow4543 MemRRow4544 1000.000000
R24544 MemRRow4544 MemRRow4545 1000.000000
R24545 MemRRow4545 MemRRow4546 1000.000000
R24546 MemRRow4546 MemRRow4547 1000.000000
R24547 MemRRow4547 MemRRow4548 1000.000000
R24548 MemRRow4548 MemRRow4549 1000.000000
R24549 MemRRow4549 MemRRow4550 1000.000000
R24550 MemRRow4550 MemRRow4551 1000.000000
R2461 MemRRow461 MemRRow462 1000.000000
R2462 MemRRow462 MemRRow463 1000.000000
R2463 MemRRow463 MemRRow464 1000.000000
R2464 MemRRow464 MemRRow465 1000.000000
R2465 MemRRow465 MemRRow466 1000.000000
R2466 MemRRow466 MemRRow467 1000.000000
R2467 MemRRow467 MemRRow468 1000.000000
R2468 MemRRow468 MemRRow469 1000.000000
R2469 MemRRow469 MemRRow4610 1000.000000
R24610 MemRRow4610 MemRRow4611 1000.000000
R24611 MemRRow4611 MemRRow4612 1000.000000
R24612 MemRRow4612 MemRRow4613 1000.000000
R24613 MemRRow4613 MemRRow4614 1000.000000
R24614 MemRRow4614 MemRRow4615 1000.000000
R24615 MemRRow4615 MemRRow4616 1000.000000
R24616 MemRRow4616 MemRRow4617 1000.000000
R24617 MemRRow4617 MemRRow4618 1000.000000
R24618 MemRRow4618 MemRRow4619 1000.000000
R24619 MemRRow4619 MemRRow4620 1000.000000
R24620 MemRRow4620 MemRRow4621 1000.000000
R24621 MemRRow4621 MemRRow4622 1000.000000
R24622 MemRRow4622 MemRRow4623 1000.000000
R24623 MemRRow4623 MemRRow4624 1000.000000
R24624 MemRRow4624 MemRRow4625 1000.000000
R24625 MemRRow4625 MemRRow4626 1000.000000
R24626 MemRRow4626 MemRRow4627 1000.000000
R24627 MemRRow4627 MemRRow4628 1000.000000
R24628 MemRRow4628 MemRRow4629 1000.000000
R24629 MemRRow4629 MemRRow4630 1000.000000
R24630 MemRRow4630 MemRRow4631 1000.000000
R24631 MemRRow4631 MemRRow4632 1000.000000
R24632 MemRRow4632 MemRRow4633 1000.000000
R24633 MemRRow4633 MemRRow4634 1000.000000
R24634 MemRRow4634 MemRRow4635 1000.000000
R24635 MemRRow4635 MemRRow4636 1000.000000
R24636 MemRRow4636 MemRRow4637 1000.000000
R24637 MemRRow4637 MemRRow4638 1000.000000
R24638 MemRRow4638 MemRRow4639 1000.000000
R24639 MemRRow4639 MemRRow4640 1000.000000
R24640 MemRRow4640 MemRRow4641 1000.000000
R24641 MemRRow4641 MemRRow4642 1000.000000
R24642 MemRRow4642 MemRRow4643 1000.000000
R24643 MemRRow4643 MemRRow4644 1000.000000
R24644 MemRRow4644 MemRRow4645 1000.000000
R24645 MemRRow4645 MemRRow4646 1000.000000
R24646 MemRRow4646 MemRRow4647 1000.000000
R24647 MemRRow4647 MemRRow4648 1000.000000
R24648 MemRRow4648 MemRRow4649 1000.000000
R24649 MemRRow4649 MemRRow4650 1000.000000
R24650 MemRRow4650 MemRRow4651 1000.000000
R2471 MemRRow471 MemRRow472 1000.000000
R2472 MemRRow472 MemRRow473 1000.000000
R2473 MemRRow473 MemRRow474 1000.000000
R2474 MemRRow474 MemRRow475 1000.000000
R2475 MemRRow475 MemRRow476 1000.000000
R2476 MemRRow476 MemRRow477 1000.000000
R2477 MemRRow477 MemRRow478 1000.000000
R2478 MemRRow478 MemRRow479 1000.000000
R2479 MemRRow479 MemRRow4710 1000.000000
R24710 MemRRow4710 MemRRow4711 1000.000000
R24711 MemRRow4711 MemRRow4712 1000.000000
R24712 MemRRow4712 MemRRow4713 1000.000000
R24713 MemRRow4713 MemRRow4714 1000.000000
R24714 MemRRow4714 MemRRow4715 1000.000000
R24715 MemRRow4715 MemRRow4716 1000.000000
R24716 MemRRow4716 MemRRow4717 1000.000000
R24717 MemRRow4717 MemRRow4718 1000.000000
R24718 MemRRow4718 MemRRow4719 1000.000000
R24719 MemRRow4719 MemRRow4720 1000.000000
R24720 MemRRow4720 MemRRow4721 1000.000000
R24721 MemRRow4721 MemRRow4722 1000.000000
R24722 MemRRow4722 MemRRow4723 1000.000000
R24723 MemRRow4723 MemRRow4724 1000.000000
R24724 MemRRow4724 MemRRow4725 1000.000000
R24725 MemRRow4725 MemRRow4726 1000.000000
R24726 MemRRow4726 MemRRow4727 1000.000000
R24727 MemRRow4727 MemRRow4728 1000.000000
R24728 MemRRow4728 MemRRow4729 1000.000000
R24729 MemRRow4729 MemRRow4730 1000.000000
R24730 MemRRow4730 MemRRow4731 1000.000000
R24731 MemRRow4731 MemRRow4732 1000.000000
R24732 MemRRow4732 MemRRow4733 1000.000000
R24733 MemRRow4733 MemRRow4734 1000.000000
R24734 MemRRow4734 MemRRow4735 1000.000000
R24735 MemRRow4735 MemRRow4736 1000.000000
R24736 MemRRow4736 MemRRow4737 1000.000000
R24737 MemRRow4737 MemRRow4738 1000.000000
R24738 MemRRow4738 MemRRow4739 1000.000000
R24739 MemRRow4739 MemRRow4740 1000.000000
R24740 MemRRow4740 MemRRow4741 1000.000000
R24741 MemRRow4741 MemRRow4742 1000.000000
R24742 MemRRow4742 MemRRow4743 1000.000000
R24743 MemRRow4743 MemRRow4744 1000.000000
R24744 MemRRow4744 MemRRow4745 1000.000000
R24745 MemRRow4745 MemRRow4746 1000.000000
R24746 MemRRow4746 MemRRow4747 1000.000000
R24747 MemRRow4747 MemRRow4748 1000.000000
R24748 MemRRow4748 MemRRow4749 1000.000000
R24749 MemRRow4749 MemRRow4750 1000.000000
R24750 MemRRow4750 MemRRow4751 1000.000000
R2481 MemRRow481 MemRRow482 1000.000000
R2482 MemRRow482 MemRRow483 1000.000000
R2483 MemRRow483 MemRRow484 1000.000000
R2484 MemRRow484 MemRRow485 1000.000000
R2485 MemRRow485 MemRRow486 1000.000000
R2486 MemRRow486 MemRRow487 1000.000000
R2487 MemRRow487 MemRRow488 1000.000000
R2488 MemRRow488 MemRRow489 1000.000000
R2489 MemRRow489 MemRRow4810 1000.000000
R24810 MemRRow4810 MemRRow4811 1000.000000
R24811 MemRRow4811 MemRRow4812 1000.000000
R24812 MemRRow4812 MemRRow4813 1000.000000
R24813 MemRRow4813 MemRRow4814 1000.000000
R24814 MemRRow4814 MemRRow4815 1000.000000
R24815 MemRRow4815 MemRRow4816 1000.000000
R24816 MemRRow4816 MemRRow4817 1000.000000
R24817 MemRRow4817 MemRRow4818 1000.000000
R24818 MemRRow4818 MemRRow4819 1000.000000
R24819 MemRRow4819 MemRRow4820 1000.000000
R24820 MemRRow4820 MemRRow4821 1000.000000
R24821 MemRRow4821 MemRRow4822 1000.000000
R24822 MemRRow4822 MemRRow4823 1000.000000
R24823 MemRRow4823 MemRRow4824 1000.000000
R24824 MemRRow4824 MemRRow4825 1000.000000
R24825 MemRRow4825 MemRRow4826 1000.000000
R24826 MemRRow4826 MemRRow4827 1000.000000
R24827 MemRRow4827 MemRRow4828 1000.000000
R24828 MemRRow4828 MemRRow4829 1000.000000
R24829 MemRRow4829 MemRRow4830 1000.000000
R24830 MemRRow4830 MemRRow4831 1000.000000
R24831 MemRRow4831 MemRRow4832 1000.000000
R24832 MemRRow4832 MemRRow4833 1000.000000
R24833 MemRRow4833 MemRRow4834 1000.000000
R24834 MemRRow4834 MemRRow4835 1000.000000
R24835 MemRRow4835 MemRRow4836 1000.000000
R24836 MemRRow4836 MemRRow4837 1000.000000
R24837 MemRRow4837 MemRRow4838 1000.000000
R24838 MemRRow4838 MemRRow4839 1000.000000
R24839 MemRRow4839 MemRRow4840 1000.000000
R24840 MemRRow4840 MemRRow4841 1000.000000
R24841 MemRRow4841 MemRRow4842 1000.000000
R24842 MemRRow4842 MemRRow4843 1000.000000
R24843 MemRRow4843 MemRRow4844 1000.000000
R24844 MemRRow4844 MemRRow4845 1000.000000
R24845 MemRRow4845 MemRRow4846 1000.000000
R24846 MemRRow4846 MemRRow4847 1000.000000
R24847 MemRRow4847 MemRRow4848 1000.000000
R24848 MemRRow4848 MemRRow4849 1000.000000
R24849 MemRRow4849 MemRRow4850 1000.000000
R24850 MemRRow4850 MemRRow4851 1000.000000
R2491 MemRRow491 MemRRow492 1000.000000
R2492 MemRRow492 MemRRow493 1000.000000
R2493 MemRRow493 MemRRow494 1000.000000
R2494 MemRRow494 MemRRow495 1000.000000
R2495 MemRRow495 MemRRow496 1000.000000
R2496 MemRRow496 MemRRow497 1000.000000
R2497 MemRRow497 MemRRow498 1000.000000
R2498 MemRRow498 MemRRow499 1000.000000
R2499 MemRRow499 MemRRow4910 1000.000000
R24910 MemRRow4910 MemRRow4911 1000.000000
R24911 MemRRow4911 MemRRow4912 1000.000000
R24912 MemRRow4912 MemRRow4913 1000.000000
R24913 MemRRow4913 MemRRow4914 1000.000000
R24914 MemRRow4914 MemRRow4915 1000.000000
R24915 MemRRow4915 MemRRow4916 1000.000000
R24916 MemRRow4916 MemRRow4917 1000.000000
R24917 MemRRow4917 MemRRow4918 1000.000000
R24918 MemRRow4918 MemRRow4919 1000.000000
R24919 MemRRow4919 MemRRow4920 1000.000000
R24920 MemRRow4920 MemRRow4921 1000.000000
R24921 MemRRow4921 MemRRow4922 1000.000000
R24922 MemRRow4922 MemRRow4923 1000.000000
R24923 MemRRow4923 MemRRow4924 1000.000000
R24924 MemRRow4924 MemRRow4925 1000.000000
R24925 MemRRow4925 MemRRow4926 1000.000000
R24926 MemRRow4926 MemRRow4927 1000.000000
R24927 MemRRow4927 MemRRow4928 1000.000000
R24928 MemRRow4928 MemRRow4929 1000.000000
R24929 MemRRow4929 MemRRow4930 1000.000000
R24930 MemRRow4930 MemRRow4931 1000.000000
R24931 MemRRow4931 MemRRow4932 1000.000000
R24932 MemRRow4932 MemRRow4933 1000.000000
R24933 MemRRow4933 MemRRow4934 1000.000000
R24934 MemRRow4934 MemRRow4935 1000.000000
R24935 MemRRow4935 MemRRow4936 1000.000000
R24936 MemRRow4936 MemRRow4937 1000.000000
R24937 MemRRow4937 MemRRow4938 1000.000000
R24938 MemRRow4938 MemRRow4939 1000.000000
R24939 MemRRow4939 MemRRow4940 1000.000000
R24940 MemRRow4940 MemRRow4941 1000.000000
R24941 MemRRow4941 MemRRow4942 1000.000000
R24942 MemRRow4942 MemRRow4943 1000.000000
R24943 MemRRow4943 MemRRow4944 1000.000000
R24944 MemRRow4944 MemRRow4945 1000.000000
R24945 MemRRow4945 MemRRow4946 1000.000000
R24946 MemRRow4946 MemRRow4947 1000.000000
R24947 MemRRow4947 MemRRow4948 1000.000000
R24948 MemRRow4948 MemRRow4949 1000.000000
R24949 MemRRow4949 MemRRow4950 1000.000000
R24950 MemRRow4950 MemRRow4951 1000.000000
R2501 MemRRow501 MemRRow502 1000.000000
R2502 MemRRow502 MemRRow503 1000.000000
R2503 MemRRow503 MemRRow504 1000.000000
R2504 MemRRow504 MemRRow505 1000.000000
R2505 MemRRow505 MemRRow506 1000.000000
R2506 MemRRow506 MemRRow507 1000.000000
R2507 MemRRow507 MemRRow508 1000.000000
R2508 MemRRow508 MemRRow509 1000.000000
R2509 MemRRow509 MemRRow5010 1000.000000
R25010 MemRRow5010 MemRRow5011 1000.000000
R25011 MemRRow5011 MemRRow5012 1000.000000
R25012 MemRRow5012 MemRRow5013 1000.000000
R25013 MemRRow5013 MemRRow5014 1000.000000
R25014 MemRRow5014 MemRRow5015 1000.000000
R25015 MemRRow5015 MemRRow5016 1000.000000
R25016 MemRRow5016 MemRRow5017 1000.000000
R25017 MemRRow5017 MemRRow5018 1000.000000
R25018 MemRRow5018 MemRRow5019 1000.000000
R25019 MemRRow5019 MemRRow5020 1000.000000
R25020 MemRRow5020 MemRRow5021 1000.000000
R25021 MemRRow5021 MemRRow5022 1000.000000
R25022 MemRRow5022 MemRRow5023 1000.000000
R25023 MemRRow5023 MemRRow5024 1000.000000
R25024 MemRRow5024 MemRRow5025 1000.000000
R25025 MemRRow5025 MemRRow5026 1000.000000
R25026 MemRRow5026 MemRRow5027 1000.000000
R25027 MemRRow5027 MemRRow5028 1000.000000
R25028 MemRRow5028 MemRRow5029 1000.000000
R25029 MemRRow5029 MemRRow5030 1000.000000
R25030 MemRRow5030 MemRRow5031 1000.000000
R25031 MemRRow5031 MemRRow5032 1000.000000
R25032 MemRRow5032 MemRRow5033 1000.000000
R25033 MemRRow5033 MemRRow5034 1000.000000
R25034 MemRRow5034 MemRRow5035 1000.000000
R25035 MemRRow5035 MemRRow5036 1000.000000
R25036 MemRRow5036 MemRRow5037 1000.000000
R25037 MemRRow5037 MemRRow5038 1000.000000
R25038 MemRRow5038 MemRRow5039 1000.000000
R25039 MemRRow5039 MemRRow5040 1000.000000
R25040 MemRRow5040 MemRRow5041 1000.000000
R25041 MemRRow5041 MemRRow5042 1000.000000
R25042 MemRRow5042 MemRRow5043 1000.000000
R25043 MemRRow5043 MemRRow5044 1000.000000
R25044 MemRRow5044 MemRRow5045 1000.000000
R25045 MemRRow5045 MemRRow5046 1000.000000
R25046 MemRRow5046 MemRRow5047 1000.000000
R25047 MemRRow5047 MemRRow5048 1000.000000
R25048 MemRRow5048 MemRRow5049 1000.000000
R25049 MemRRow5049 MemRRow5050 1000.000000
R25050 MemRRow5050 MemRRow5051 1000.000000

*Line Column Resistances
R311 MemRCol11 MemRCol21 1000.000000
R312 MemRCol12 MemRCol22 1000.000000
R313 MemRCol13 MemRCol23 1000.000000
R314 MemRCol14 MemRCol24 1000.000000
R315 MemRCol15 MemRCol25 1000.000000
R316 MemRCol16 MemRCol26 1000.000000
R317 MemRCol17 MemRCol27 1000.000000
R318 MemRCol18 MemRCol28 1000.000000
R319 MemRCol19 MemRCol29 1000.000000
R3110 MemRCol110 MemRCol210 1000.000000
R3111 MemRCol111 MemRCol211 1000.000000
R3112 MemRCol112 MemRCol212 1000.000000
R3113 MemRCol113 MemRCol213 1000.000000
R3114 MemRCol114 MemRCol214 1000.000000
R3115 MemRCol115 MemRCol215 1000.000000
R3116 MemRCol116 MemRCol216 1000.000000
R3117 MemRCol117 MemRCol217 1000.000000
R3118 MemRCol118 MemRCol218 1000.000000
R3119 MemRCol119 MemRCol219 1000.000000
R3120 MemRCol120 MemRCol220 1000.000000
R3121 MemRCol121 MemRCol221 1000.000000
R3122 MemRCol122 MemRCol222 1000.000000
R3123 MemRCol123 MemRCol223 1000.000000
R3124 MemRCol124 MemRCol224 1000.000000
R3125 MemRCol125 MemRCol225 1000.000000
R3126 MemRCol126 MemRCol226 1000.000000
R3127 MemRCol127 MemRCol227 1000.000000
R3128 MemRCol128 MemRCol228 1000.000000
R3129 MemRCol129 MemRCol229 1000.000000
R3130 MemRCol130 MemRCol230 1000.000000
R3131 MemRCol131 MemRCol231 1000.000000
R3132 MemRCol132 MemRCol232 1000.000000
R3133 MemRCol133 MemRCol233 1000.000000
R3134 MemRCol134 MemRCol234 1000.000000
R3135 MemRCol135 MemRCol235 1000.000000
R3136 MemRCol136 MemRCol236 1000.000000
R3137 MemRCol137 MemRCol237 1000.000000
R3138 MemRCol138 MemRCol238 1000.000000
R3139 MemRCol139 MemRCol239 1000.000000
R3140 MemRCol140 MemRCol240 1000.000000
R3141 MemRCol141 MemRCol241 1000.000000
R3142 MemRCol142 MemRCol242 1000.000000
R3143 MemRCol143 MemRCol243 1000.000000
R3144 MemRCol144 MemRCol244 1000.000000
R3145 MemRCol145 MemRCol245 1000.000000
R3146 MemRCol146 MemRCol246 1000.000000
R3147 MemRCol147 MemRCol247 1000.000000
R3148 MemRCol148 MemRCol248 1000.000000
R3149 MemRCol149 MemRCol249 1000.000000
R3150 MemRCol150 MemRCol250 1000.000000
R321 MemRCol21 MemRCol31 1000.000000
R322 MemRCol22 MemRCol32 1000.000000
R323 MemRCol23 MemRCol33 1000.000000
R324 MemRCol24 MemRCol34 1000.000000
R325 MemRCol25 MemRCol35 1000.000000
R326 MemRCol26 MemRCol36 1000.000000
R327 MemRCol27 MemRCol37 1000.000000
R328 MemRCol28 MemRCol38 1000.000000
R329 MemRCol29 MemRCol39 1000.000000
R3210 MemRCol210 MemRCol310 1000.000000
R3211 MemRCol211 MemRCol311 1000.000000
R3212 MemRCol212 MemRCol312 1000.000000
R3213 MemRCol213 MemRCol313 1000.000000
R3214 MemRCol214 MemRCol314 1000.000000
R3215 MemRCol215 MemRCol315 1000.000000
R3216 MemRCol216 MemRCol316 1000.000000
R3217 MemRCol217 MemRCol317 1000.000000
R3218 MemRCol218 MemRCol318 1000.000000
R3219 MemRCol219 MemRCol319 1000.000000
R3220 MemRCol220 MemRCol320 1000.000000
R3221 MemRCol221 MemRCol321 1000.000000
R3222 MemRCol222 MemRCol322 1000.000000
R3223 MemRCol223 MemRCol323 1000.000000
R3224 MemRCol224 MemRCol324 1000.000000
R3225 MemRCol225 MemRCol325 1000.000000
R3226 MemRCol226 MemRCol326 1000.000000
R3227 MemRCol227 MemRCol327 1000.000000
R3228 MemRCol228 MemRCol328 1000.000000
R3229 MemRCol229 MemRCol329 1000.000000
R3230 MemRCol230 MemRCol330 1000.000000
R3231 MemRCol231 MemRCol331 1000.000000
R3232 MemRCol232 MemRCol332 1000.000000
R3233 MemRCol233 MemRCol333 1000.000000
R3234 MemRCol234 MemRCol334 1000.000000
R3235 MemRCol235 MemRCol335 1000.000000
R3236 MemRCol236 MemRCol336 1000.000000
R3237 MemRCol237 MemRCol337 1000.000000
R3238 MemRCol238 MemRCol338 1000.000000
R3239 MemRCol239 MemRCol339 1000.000000
R3240 MemRCol240 MemRCol340 1000.000000
R3241 MemRCol241 MemRCol341 1000.000000
R3242 MemRCol242 MemRCol342 1000.000000
R3243 MemRCol243 MemRCol343 1000.000000
R3244 MemRCol244 MemRCol344 1000.000000
R3245 MemRCol245 MemRCol345 1000.000000
R3246 MemRCol246 MemRCol346 1000.000000
R3247 MemRCol247 MemRCol347 1000.000000
R3248 MemRCol248 MemRCol348 1000.000000
R3249 MemRCol249 MemRCol349 1000.000000
R3250 MemRCol250 MemRCol350 1000.000000
R331 MemRCol31 MemRCol41 1000.000000
R332 MemRCol32 MemRCol42 1000.000000
R333 MemRCol33 MemRCol43 1000.000000
R334 MemRCol34 MemRCol44 1000.000000
R335 MemRCol35 MemRCol45 1000.000000
R336 MemRCol36 MemRCol46 1000.000000
R337 MemRCol37 MemRCol47 1000.000000
R338 MemRCol38 MemRCol48 1000.000000
R339 MemRCol39 MemRCol49 1000.000000
R3310 MemRCol310 MemRCol410 1000.000000
R3311 MemRCol311 MemRCol411 1000.000000
R3312 MemRCol312 MemRCol412 1000.000000
R3313 MemRCol313 MemRCol413 1000.000000
R3314 MemRCol314 MemRCol414 1000.000000
R3315 MemRCol315 MemRCol415 1000.000000
R3316 MemRCol316 MemRCol416 1000.000000
R3317 MemRCol317 MemRCol417 1000.000000
R3318 MemRCol318 MemRCol418 1000.000000
R3319 MemRCol319 MemRCol419 1000.000000
R3320 MemRCol320 MemRCol420 1000.000000
R3321 MemRCol321 MemRCol421 1000.000000
R3322 MemRCol322 MemRCol422 1000.000000
R3323 MemRCol323 MemRCol423 1000.000000
R3324 MemRCol324 MemRCol424 1000.000000
R3325 MemRCol325 MemRCol425 1000.000000
R3326 MemRCol326 MemRCol426 1000.000000
R3327 MemRCol327 MemRCol427 1000.000000
R3328 MemRCol328 MemRCol428 1000.000000
R3329 MemRCol329 MemRCol429 1000.000000
R3330 MemRCol330 MemRCol430 1000.000000
R3331 MemRCol331 MemRCol431 1000.000000
R3332 MemRCol332 MemRCol432 1000.000000
R3333 MemRCol333 MemRCol433 1000.000000
R3334 MemRCol334 MemRCol434 1000.000000
R3335 MemRCol335 MemRCol435 1000.000000
R3336 MemRCol336 MemRCol436 1000.000000
R3337 MemRCol337 MemRCol437 1000.000000
R3338 MemRCol338 MemRCol438 1000.000000
R3339 MemRCol339 MemRCol439 1000.000000
R3340 MemRCol340 MemRCol440 1000.000000
R3341 MemRCol341 MemRCol441 1000.000000
R3342 MemRCol342 MemRCol442 1000.000000
R3343 MemRCol343 MemRCol443 1000.000000
R3344 MemRCol344 MemRCol444 1000.000000
R3345 MemRCol345 MemRCol445 1000.000000
R3346 MemRCol346 MemRCol446 1000.000000
R3347 MemRCol347 MemRCol447 1000.000000
R3348 MemRCol348 MemRCol448 1000.000000
R3349 MemRCol349 MemRCol449 1000.000000
R3350 MemRCol350 MemRCol450 1000.000000
R341 MemRCol41 MemRCol51 1000.000000
R342 MemRCol42 MemRCol52 1000.000000
R343 MemRCol43 MemRCol53 1000.000000
R344 MemRCol44 MemRCol54 1000.000000
R345 MemRCol45 MemRCol55 1000.000000
R346 MemRCol46 MemRCol56 1000.000000
R347 MemRCol47 MemRCol57 1000.000000
R348 MemRCol48 MemRCol58 1000.000000
R349 MemRCol49 MemRCol59 1000.000000
R3410 MemRCol410 MemRCol510 1000.000000
R3411 MemRCol411 MemRCol511 1000.000000
R3412 MemRCol412 MemRCol512 1000.000000
R3413 MemRCol413 MemRCol513 1000.000000
R3414 MemRCol414 MemRCol514 1000.000000
R3415 MemRCol415 MemRCol515 1000.000000
R3416 MemRCol416 MemRCol516 1000.000000
R3417 MemRCol417 MemRCol517 1000.000000
R3418 MemRCol418 MemRCol518 1000.000000
R3419 MemRCol419 MemRCol519 1000.000000
R3420 MemRCol420 MemRCol520 1000.000000
R3421 MemRCol421 MemRCol521 1000.000000
R3422 MemRCol422 MemRCol522 1000.000000
R3423 MemRCol423 MemRCol523 1000.000000
R3424 MemRCol424 MemRCol524 1000.000000
R3425 MemRCol425 MemRCol525 1000.000000
R3426 MemRCol426 MemRCol526 1000.000000
R3427 MemRCol427 MemRCol527 1000.000000
R3428 MemRCol428 MemRCol528 1000.000000
R3429 MemRCol429 MemRCol529 1000.000000
R3430 MemRCol430 MemRCol530 1000.000000
R3431 MemRCol431 MemRCol531 1000.000000
R3432 MemRCol432 MemRCol532 1000.000000
R3433 MemRCol433 MemRCol533 1000.000000
R3434 MemRCol434 MemRCol534 1000.000000
R3435 MemRCol435 MemRCol535 1000.000000
R3436 MemRCol436 MemRCol536 1000.000000
R3437 MemRCol437 MemRCol537 1000.000000
R3438 MemRCol438 MemRCol538 1000.000000
R3439 MemRCol439 MemRCol539 1000.000000
R3440 MemRCol440 MemRCol540 1000.000000
R3441 MemRCol441 MemRCol541 1000.000000
R3442 MemRCol442 MemRCol542 1000.000000
R3443 MemRCol443 MemRCol543 1000.000000
R3444 MemRCol444 MemRCol544 1000.000000
R3445 MemRCol445 MemRCol545 1000.000000
R3446 MemRCol446 MemRCol546 1000.000000
R3447 MemRCol447 MemRCol547 1000.000000
R3448 MemRCol448 MemRCol548 1000.000000
R3449 MemRCol449 MemRCol549 1000.000000
R3450 MemRCol450 MemRCol550 1000.000000
R351 MemRCol51 MemRCol61 1000.000000
R352 MemRCol52 MemRCol62 1000.000000
R353 MemRCol53 MemRCol63 1000.000000
R354 MemRCol54 MemRCol64 1000.000000
R355 MemRCol55 MemRCol65 1000.000000
R356 MemRCol56 MemRCol66 1000.000000
R357 MemRCol57 MemRCol67 1000.000000
R358 MemRCol58 MemRCol68 1000.000000
R359 MemRCol59 MemRCol69 1000.000000
R3510 MemRCol510 MemRCol610 1000.000000
R3511 MemRCol511 MemRCol611 1000.000000
R3512 MemRCol512 MemRCol612 1000.000000
R3513 MemRCol513 MemRCol613 1000.000000
R3514 MemRCol514 MemRCol614 1000.000000
R3515 MemRCol515 MemRCol615 1000.000000
R3516 MemRCol516 MemRCol616 1000.000000
R3517 MemRCol517 MemRCol617 1000.000000
R3518 MemRCol518 MemRCol618 1000.000000
R3519 MemRCol519 MemRCol619 1000.000000
R3520 MemRCol520 MemRCol620 1000.000000
R3521 MemRCol521 MemRCol621 1000.000000
R3522 MemRCol522 MemRCol622 1000.000000
R3523 MemRCol523 MemRCol623 1000.000000
R3524 MemRCol524 MemRCol624 1000.000000
R3525 MemRCol525 MemRCol625 1000.000000
R3526 MemRCol526 MemRCol626 1000.000000
R3527 MemRCol527 MemRCol627 1000.000000
R3528 MemRCol528 MemRCol628 1000.000000
R3529 MemRCol529 MemRCol629 1000.000000
R3530 MemRCol530 MemRCol630 1000.000000
R3531 MemRCol531 MemRCol631 1000.000000
R3532 MemRCol532 MemRCol632 1000.000000
R3533 MemRCol533 MemRCol633 1000.000000
R3534 MemRCol534 MemRCol634 1000.000000
R3535 MemRCol535 MemRCol635 1000.000000
R3536 MemRCol536 MemRCol636 1000.000000
R3537 MemRCol537 MemRCol637 1000.000000
R3538 MemRCol538 MemRCol638 1000.000000
R3539 MemRCol539 MemRCol639 1000.000000
R3540 MemRCol540 MemRCol640 1000.000000
R3541 MemRCol541 MemRCol641 1000.000000
R3542 MemRCol542 MemRCol642 1000.000000
R3543 MemRCol543 MemRCol643 1000.000000
R3544 MemRCol544 MemRCol644 1000.000000
R3545 MemRCol545 MemRCol645 1000.000000
R3546 MemRCol546 MemRCol646 1000.000000
R3547 MemRCol547 MemRCol647 1000.000000
R3548 MemRCol548 MemRCol648 1000.000000
R3549 MemRCol549 MemRCol649 1000.000000
R3550 MemRCol550 MemRCol650 1000.000000
R361 MemRCol61 MemRCol71 1000.000000
R362 MemRCol62 MemRCol72 1000.000000
R363 MemRCol63 MemRCol73 1000.000000
R364 MemRCol64 MemRCol74 1000.000000
R365 MemRCol65 MemRCol75 1000.000000
R366 MemRCol66 MemRCol76 1000.000000
R367 MemRCol67 MemRCol77 1000.000000
R368 MemRCol68 MemRCol78 1000.000000
R369 MemRCol69 MemRCol79 1000.000000
R3610 MemRCol610 MemRCol710 1000.000000
R3611 MemRCol611 MemRCol711 1000.000000
R3612 MemRCol612 MemRCol712 1000.000000
R3613 MemRCol613 MemRCol713 1000.000000
R3614 MemRCol614 MemRCol714 1000.000000
R3615 MemRCol615 MemRCol715 1000.000000
R3616 MemRCol616 MemRCol716 1000.000000
R3617 MemRCol617 MemRCol717 1000.000000
R3618 MemRCol618 MemRCol718 1000.000000
R3619 MemRCol619 MemRCol719 1000.000000
R3620 MemRCol620 MemRCol720 1000.000000
R3621 MemRCol621 MemRCol721 1000.000000
R3622 MemRCol622 MemRCol722 1000.000000
R3623 MemRCol623 MemRCol723 1000.000000
R3624 MemRCol624 MemRCol724 1000.000000
R3625 MemRCol625 MemRCol725 1000.000000
R3626 MemRCol626 MemRCol726 1000.000000
R3627 MemRCol627 MemRCol727 1000.000000
R3628 MemRCol628 MemRCol728 1000.000000
R3629 MemRCol629 MemRCol729 1000.000000
R3630 MemRCol630 MemRCol730 1000.000000
R3631 MemRCol631 MemRCol731 1000.000000
R3632 MemRCol632 MemRCol732 1000.000000
R3633 MemRCol633 MemRCol733 1000.000000
R3634 MemRCol634 MemRCol734 1000.000000
R3635 MemRCol635 MemRCol735 1000.000000
R3636 MemRCol636 MemRCol736 1000.000000
R3637 MemRCol637 MemRCol737 1000.000000
R3638 MemRCol638 MemRCol738 1000.000000
R3639 MemRCol639 MemRCol739 1000.000000
R3640 MemRCol640 MemRCol740 1000.000000
R3641 MemRCol641 MemRCol741 1000.000000
R3642 MemRCol642 MemRCol742 1000.000000
R3643 MemRCol643 MemRCol743 1000.000000
R3644 MemRCol644 MemRCol744 1000.000000
R3645 MemRCol645 MemRCol745 1000.000000
R3646 MemRCol646 MemRCol746 1000.000000
R3647 MemRCol647 MemRCol747 1000.000000
R3648 MemRCol648 MemRCol748 1000.000000
R3649 MemRCol649 MemRCol749 1000.000000
R3650 MemRCol650 MemRCol750 1000.000000
R371 MemRCol71 MemRCol81 1000.000000
R372 MemRCol72 MemRCol82 1000.000000
R373 MemRCol73 MemRCol83 1000.000000
R374 MemRCol74 MemRCol84 1000.000000
R375 MemRCol75 MemRCol85 1000.000000
R376 MemRCol76 MemRCol86 1000.000000
R377 MemRCol77 MemRCol87 1000.000000
R378 MemRCol78 MemRCol88 1000.000000
R379 MemRCol79 MemRCol89 1000.000000
R3710 MemRCol710 MemRCol810 1000.000000
R3711 MemRCol711 MemRCol811 1000.000000
R3712 MemRCol712 MemRCol812 1000.000000
R3713 MemRCol713 MemRCol813 1000.000000
R3714 MemRCol714 MemRCol814 1000.000000
R3715 MemRCol715 MemRCol815 1000.000000
R3716 MemRCol716 MemRCol816 1000.000000
R3717 MemRCol717 MemRCol817 1000.000000
R3718 MemRCol718 MemRCol818 1000.000000
R3719 MemRCol719 MemRCol819 1000.000000
R3720 MemRCol720 MemRCol820 1000.000000
R3721 MemRCol721 MemRCol821 1000.000000
R3722 MemRCol722 MemRCol822 1000.000000
R3723 MemRCol723 MemRCol823 1000.000000
R3724 MemRCol724 MemRCol824 1000.000000
R3725 MemRCol725 MemRCol825 1000.000000
R3726 MemRCol726 MemRCol826 1000.000000
R3727 MemRCol727 MemRCol827 1000.000000
R3728 MemRCol728 MemRCol828 1000.000000
R3729 MemRCol729 MemRCol829 1000.000000
R3730 MemRCol730 MemRCol830 1000.000000
R3731 MemRCol731 MemRCol831 1000.000000
R3732 MemRCol732 MemRCol832 1000.000000
R3733 MemRCol733 MemRCol833 1000.000000
R3734 MemRCol734 MemRCol834 1000.000000
R3735 MemRCol735 MemRCol835 1000.000000
R3736 MemRCol736 MemRCol836 1000.000000
R3737 MemRCol737 MemRCol837 1000.000000
R3738 MemRCol738 MemRCol838 1000.000000
R3739 MemRCol739 MemRCol839 1000.000000
R3740 MemRCol740 MemRCol840 1000.000000
R3741 MemRCol741 MemRCol841 1000.000000
R3742 MemRCol742 MemRCol842 1000.000000
R3743 MemRCol743 MemRCol843 1000.000000
R3744 MemRCol744 MemRCol844 1000.000000
R3745 MemRCol745 MemRCol845 1000.000000
R3746 MemRCol746 MemRCol846 1000.000000
R3747 MemRCol747 MemRCol847 1000.000000
R3748 MemRCol748 MemRCol848 1000.000000
R3749 MemRCol749 MemRCol849 1000.000000
R3750 MemRCol750 MemRCol850 1000.000000
R381 MemRCol81 MemRCol91 1000.000000
R382 MemRCol82 MemRCol92 1000.000000
R383 MemRCol83 MemRCol93 1000.000000
R384 MemRCol84 MemRCol94 1000.000000
R385 MemRCol85 MemRCol95 1000.000000
R386 MemRCol86 MemRCol96 1000.000000
R387 MemRCol87 MemRCol97 1000.000000
R388 MemRCol88 MemRCol98 1000.000000
R389 MemRCol89 MemRCol99 1000.000000
R3810 MemRCol810 MemRCol910 1000.000000
R3811 MemRCol811 MemRCol911 1000.000000
R3812 MemRCol812 MemRCol912 1000.000000
R3813 MemRCol813 MemRCol913 1000.000000
R3814 MemRCol814 MemRCol914 1000.000000
R3815 MemRCol815 MemRCol915 1000.000000
R3816 MemRCol816 MemRCol916 1000.000000
R3817 MemRCol817 MemRCol917 1000.000000
R3818 MemRCol818 MemRCol918 1000.000000
R3819 MemRCol819 MemRCol919 1000.000000
R3820 MemRCol820 MemRCol920 1000.000000
R3821 MemRCol821 MemRCol921 1000.000000
R3822 MemRCol822 MemRCol922 1000.000000
R3823 MemRCol823 MemRCol923 1000.000000
R3824 MemRCol824 MemRCol924 1000.000000
R3825 MemRCol825 MemRCol925 1000.000000
R3826 MemRCol826 MemRCol926 1000.000000
R3827 MemRCol827 MemRCol927 1000.000000
R3828 MemRCol828 MemRCol928 1000.000000
R3829 MemRCol829 MemRCol929 1000.000000
R3830 MemRCol830 MemRCol930 1000.000000
R3831 MemRCol831 MemRCol931 1000.000000
R3832 MemRCol832 MemRCol932 1000.000000
R3833 MemRCol833 MemRCol933 1000.000000
R3834 MemRCol834 MemRCol934 1000.000000
R3835 MemRCol835 MemRCol935 1000.000000
R3836 MemRCol836 MemRCol936 1000.000000
R3837 MemRCol837 MemRCol937 1000.000000
R3838 MemRCol838 MemRCol938 1000.000000
R3839 MemRCol839 MemRCol939 1000.000000
R3840 MemRCol840 MemRCol940 1000.000000
R3841 MemRCol841 MemRCol941 1000.000000
R3842 MemRCol842 MemRCol942 1000.000000
R3843 MemRCol843 MemRCol943 1000.000000
R3844 MemRCol844 MemRCol944 1000.000000
R3845 MemRCol845 MemRCol945 1000.000000
R3846 MemRCol846 MemRCol946 1000.000000
R3847 MemRCol847 MemRCol947 1000.000000
R3848 MemRCol848 MemRCol948 1000.000000
R3849 MemRCol849 MemRCol949 1000.000000
R3850 MemRCol850 MemRCol950 1000.000000
R391 MemRCol91 MemRCol101 1000.000000
R392 MemRCol92 MemRCol102 1000.000000
R393 MemRCol93 MemRCol103 1000.000000
R394 MemRCol94 MemRCol104 1000.000000
R395 MemRCol95 MemRCol105 1000.000000
R396 MemRCol96 MemRCol106 1000.000000
R397 MemRCol97 MemRCol107 1000.000000
R398 MemRCol98 MemRCol108 1000.000000
R399 MemRCol99 MemRCol109 1000.000000
R3910 MemRCol910 MemRCol1010 1000.000000
R3911 MemRCol911 MemRCol1011 1000.000000
R3912 MemRCol912 MemRCol1012 1000.000000
R3913 MemRCol913 MemRCol1013 1000.000000
R3914 MemRCol914 MemRCol1014 1000.000000
R3915 MemRCol915 MemRCol1015 1000.000000
R3916 MemRCol916 MemRCol1016 1000.000000
R3917 MemRCol917 MemRCol1017 1000.000000
R3918 MemRCol918 MemRCol1018 1000.000000
R3919 MemRCol919 MemRCol1019 1000.000000
R3920 MemRCol920 MemRCol1020 1000.000000
R3921 MemRCol921 MemRCol1021 1000.000000
R3922 MemRCol922 MemRCol1022 1000.000000
R3923 MemRCol923 MemRCol1023 1000.000000
R3924 MemRCol924 MemRCol1024 1000.000000
R3925 MemRCol925 MemRCol1025 1000.000000
R3926 MemRCol926 MemRCol1026 1000.000000
R3927 MemRCol927 MemRCol1027 1000.000000
R3928 MemRCol928 MemRCol1028 1000.000000
R3929 MemRCol929 MemRCol1029 1000.000000
R3930 MemRCol930 MemRCol1030 1000.000000
R3931 MemRCol931 MemRCol1031 1000.000000
R3932 MemRCol932 MemRCol1032 1000.000000
R3933 MemRCol933 MemRCol1033 1000.000000
R3934 MemRCol934 MemRCol1034 1000.000000
R3935 MemRCol935 MemRCol1035 1000.000000
R3936 MemRCol936 MemRCol1036 1000.000000
R3937 MemRCol937 MemRCol1037 1000.000000
R3938 MemRCol938 MemRCol1038 1000.000000
R3939 MemRCol939 MemRCol1039 1000.000000
R3940 MemRCol940 MemRCol1040 1000.000000
R3941 MemRCol941 MemRCol1041 1000.000000
R3942 MemRCol942 MemRCol1042 1000.000000
R3943 MemRCol943 MemRCol1043 1000.000000
R3944 MemRCol944 MemRCol1044 1000.000000
R3945 MemRCol945 MemRCol1045 1000.000000
R3946 MemRCol946 MemRCol1046 1000.000000
R3947 MemRCol947 MemRCol1047 1000.000000
R3948 MemRCol948 MemRCol1048 1000.000000
R3949 MemRCol949 MemRCol1049 1000.000000
R3950 MemRCol950 MemRCol1050 1000.000000
R3101 MemRCol101 MemRCol111 1000.000000
R3102 MemRCol102 MemRCol112 1000.000000
R3103 MemRCol103 MemRCol113 1000.000000
R3104 MemRCol104 MemRCol114 1000.000000
R3105 MemRCol105 MemRCol115 1000.000000
R3106 MemRCol106 MemRCol116 1000.000000
R3107 MemRCol107 MemRCol117 1000.000000
R3108 MemRCol108 MemRCol118 1000.000000
R3109 MemRCol109 MemRCol119 1000.000000
R31010 MemRCol1010 MemRCol1110 1000.000000
R31011 MemRCol1011 MemRCol1111 1000.000000
R31012 MemRCol1012 MemRCol1112 1000.000000
R31013 MemRCol1013 MemRCol1113 1000.000000
R31014 MemRCol1014 MemRCol1114 1000.000000
R31015 MemRCol1015 MemRCol1115 1000.000000
R31016 MemRCol1016 MemRCol1116 1000.000000
R31017 MemRCol1017 MemRCol1117 1000.000000
R31018 MemRCol1018 MemRCol1118 1000.000000
R31019 MemRCol1019 MemRCol1119 1000.000000
R31020 MemRCol1020 MemRCol1120 1000.000000
R31021 MemRCol1021 MemRCol1121 1000.000000
R31022 MemRCol1022 MemRCol1122 1000.000000
R31023 MemRCol1023 MemRCol1123 1000.000000
R31024 MemRCol1024 MemRCol1124 1000.000000
R31025 MemRCol1025 MemRCol1125 1000.000000
R31026 MemRCol1026 MemRCol1126 1000.000000
R31027 MemRCol1027 MemRCol1127 1000.000000
R31028 MemRCol1028 MemRCol1128 1000.000000
R31029 MemRCol1029 MemRCol1129 1000.000000
R31030 MemRCol1030 MemRCol1130 1000.000000
R31031 MemRCol1031 MemRCol1131 1000.000000
R31032 MemRCol1032 MemRCol1132 1000.000000
R31033 MemRCol1033 MemRCol1133 1000.000000
R31034 MemRCol1034 MemRCol1134 1000.000000
R31035 MemRCol1035 MemRCol1135 1000.000000
R31036 MemRCol1036 MemRCol1136 1000.000000
R31037 MemRCol1037 MemRCol1137 1000.000000
R31038 MemRCol1038 MemRCol1138 1000.000000
R31039 MemRCol1039 MemRCol1139 1000.000000
R31040 MemRCol1040 MemRCol1140 1000.000000
R31041 MemRCol1041 MemRCol1141 1000.000000
R31042 MemRCol1042 MemRCol1142 1000.000000
R31043 MemRCol1043 MemRCol1143 1000.000000
R31044 MemRCol1044 MemRCol1144 1000.000000
R31045 MemRCol1045 MemRCol1145 1000.000000
R31046 MemRCol1046 MemRCol1146 1000.000000
R31047 MemRCol1047 MemRCol1147 1000.000000
R31048 MemRCol1048 MemRCol1148 1000.000000
R31049 MemRCol1049 MemRCol1149 1000.000000
R31050 MemRCol1050 MemRCol1150 1000.000000
R3111 MemRCol111 MemRCol121 1000.000000
R3112 MemRCol112 MemRCol122 1000.000000
R3113 MemRCol113 MemRCol123 1000.000000
R3114 MemRCol114 MemRCol124 1000.000000
R3115 MemRCol115 MemRCol125 1000.000000
R3116 MemRCol116 MemRCol126 1000.000000
R3117 MemRCol117 MemRCol127 1000.000000
R3118 MemRCol118 MemRCol128 1000.000000
R3119 MemRCol119 MemRCol129 1000.000000
R31110 MemRCol1110 MemRCol1210 1000.000000
R31111 MemRCol1111 MemRCol1211 1000.000000
R31112 MemRCol1112 MemRCol1212 1000.000000
R31113 MemRCol1113 MemRCol1213 1000.000000
R31114 MemRCol1114 MemRCol1214 1000.000000
R31115 MemRCol1115 MemRCol1215 1000.000000
R31116 MemRCol1116 MemRCol1216 1000.000000
R31117 MemRCol1117 MemRCol1217 1000.000000
R31118 MemRCol1118 MemRCol1218 1000.000000
R31119 MemRCol1119 MemRCol1219 1000.000000
R31120 MemRCol1120 MemRCol1220 1000.000000
R31121 MemRCol1121 MemRCol1221 1000.000000
R31122 MemRCol1122 MemRCol1222 1000.000000
R31123 MemRCol1123 MemRCol1223 1000.000000
R31124 MemRCol1124 MemRCol1224 1000.000000
R31125 MemRCol1125 MemRCol1225 1000.000000
R31126 MemRCol1126 MemRCol1226 1000.000000
R31127 MemRCol1127 MemRCol1227 1000.000000
R31128 MemRCol1128 MemRCol1228 1000.000000
R31129 MemRCol1129 MemRCol1229 1000.000000
R31130 MemRCol1130 MemRCol1230 1000.000000
R31131 MemRCol1131 MemRCol1231 1000.000000
R31132 MemRCol1132 MemRCol1232 1000.000000
R31133 MemRCol1133 MemRCol1233 1000.000000
R31134 MemRCol1134 MemRCol1234 1000.000000
R31135 MemRCol1135 MemRCol1235 1000.000000
R31136 MemRCol1136 MemRCol1236 1000.000000
R31137 MemRCol1137 MemRCol1237 1000.000000
R31138 MemRCol1138 MemRCol1238 1000.000000
R31139 MemRCol1139 MemRCol1239 1000.000000
R31140 MemRCol1140 MemRCol1240 1000.000000
R31141 MemRCol1141 MemRCol1241 1000.000000
R31142 MemRCol1142 MemRCol1242 1000.000000
R31143 MemRCol1143 MemRCol1243 1000.000000
R31144 MemRCol1144 MemRCol1244 1000.000000
R31145 MemRCol1145 MemRCol1245 1000.000000
R31146 MemRCol1146 MemRCol1246 1000.000000
R31147 MemRCol1147 MemRCol1247 1000.000000
R31148 MemRCol1148 MemRCol1248 1000.000000
R31149 MemRCol1149 MemRCol1249 1000.000000
R31150 MemRCol1150 MemRCol1250 1000.000000
R3121 MemRCol121 MemRCol131 1000.000000
R3122 MemRCol122 MemRCol132 1000.000000
R3123 MemRCol123 MemRCol133 1000.000000
R3124 MemRCol124 MemRCol134 1000.000000
R3125 MemRCol125 MemRCol135 1000.000000
R3126 MemRCol126 MemRCol136 1000.000000
R3127 MemRCol127 MemRCol137 1000.000000
R3128 MemRCol128 MemRCol138 1000.000000
R3129 MemRCol129 MemRCol139 1000.000000
R31210 MemRCol1210 MemRCol1310 1000.000000
R31211 MemRCol1211 MemRCol1311 1000.000000
R31212 MemRCol1212 MemRCol1312 1000.000000
R31213 MemRCol1213 MemRCol1313 1000.000000
R31214 MemRCol1214 MemRCol1314 1000.000000
R31215 MemRCol1215 MemRCol1315 1000.000000
R31216 MemRCol1216 MemRCol1316 1000.000000
R31217 MemRCol1217 MemRCol1317 1000.000000
R31218 MemRCol1218 MemRCol1318 1000.000000
R31219 MemRCol1219 MemRCol1319 1000.000000
R31220 MemRCol1220 MemRCol1320 1000.000000
R31221 MemRCol1221 MemRCol1321 1000.000000
R31222 MemRCol1222 MemRCol1322 1000.000000
R31223 MemRCol1223 MemRCol1323 1000.000000
R31224 MemRCol1224 MemRCol1324 1000.000000
R31225 MemRCol1225 MemRCol1325 1000.000000
R31226 MemRCol1226 MemRCol1326 1000.000000
R31227 MemRCol1227 MemRCol1327 1000.000000
R31228 MemRCol1228 MemRCol1328 1000.000000
R31229 MemRCol1229 MemRCol1329 1000.000000
R31230 MemRCol1230 MemRCol1330 1000.000000
R31231 MemRCol1231 MemRCol1331 1000.000000
R31232 MemRCol1232 MemRCol1332 1000.000000
R31233 MemRCol1233 MemRCol1333 1000.000000
R31234 MemRCol1234 MemRCol1334 1000.000000
R31235 MemRCol1235 MemRCol1335 1000.000000
R31236 MemRCol1236 MemRCol1336 1000.000000
R31237 MemRCol1237 MemRCol1337 1000.000000
R31238 MemRCol1238 MemRCol1338 1000.000000
R31239 MemRCol1239 MemRCol1339 1000.000000
R31240 MemRCol1240 MemRCol1340 1000.000000
R31241 MemRCol1241 MemRCol1341 1000.000000
R31242 MemRCol1242 MemRCol1342 1000.000000
R31243 MemRCol1243 MemRCol1343 1000.000000
R31244 MemRCol1244 MemRCol1344 1000.000000
R31245 MemRCol1245 MemRCol1345 1000.000000
R31246 MemRCol1246 MemRCol1346 1000.000000
R31247 MemRCol1247 MemRCol1347 1000.000000
R31248 MemRCol1248 MemRCol1348 1000.000000
R31249 MemRCol1249 MemRCol1349 1000.000000
R31250 MemRCol1250 MemRCol1350 1000.000000
R3131 MemRCol131 MemRCol141 1000.000000
R3132 MemRCol132 MemRCol142 1000.000000
R3133 MemRCol133 MemRCol143 1000.000000
R3134 MemRCol134 MemRCol144 1000.000000
R3135 MemRCol135 MemRCol145 1000.000000
R3136 MemRCol136 MemRCol146 1000.000000
R3137 MemRCol137 MemRCol147 1000.000000
R3138 MemRCol138 MemRCol148 1000.000000
R3139 MemRCol139 MemRCol149 1000.000000
R31310 MemRCol1310 MemRCol1410 1000.000000
R31311 MemRCol1311 MemRCol1411 1000.000000
R31312 MemRCol1312 MemRCol1412 1000.000000
R31313 MemRCol1313 MemRCol1413 1000.000000
R31314 MemRCol1314 MemRCol1414 1000.000000
R31315 MemRCol1315 MemRCol1415 1000.000000
R31316 MemRCol1316 MemRCol1416 1000.000000
R31317 MemRCol1317 MemRCol1417 1000.000000
R31318 MemRCol1318 MemRCol1418 1000.000000
R31319 MemRCol1319 MemRCol1419 1000.000000
R31320 MemRCol1320 MemRCol1420 1000.000000
R31321 MemRCol1321 MemRCol1421 1000.000000
R31322 MemRCol1322 MemRCol1422 1000.000000
R31323 MemRCol1323 MemRCol1423 1000.000000
R31324 MemRCol1324 MemRCol1424 1000.000000
R31325 MemRCol1325 MemRCol1425 1000.000000
R31326 MemRCol1326 MemRCol1426 1000.000000
R31327 MemRCol1327 MemRCol1427 1000.000000
R31328 MemRCol1328 MemRCol1428 1000.000000
R31329 MemRCol1329 MemRCol1429 1000.000000
R31330 MemRCol1330 MemRCol1430 1000.000000
R31331 MemRCol1331 MemRCol1431 1000.000000
R31332 MemRCol1332 MemRCol1432 1000.000000
R31333 MemRCol1333 MemRCol1433 1000.000000
R31334 MemRCol1334 MemRCol1434 1000.000000
R31335 MemRCol1335 MemRCol1435 1000.000000
R31336 MemRCol1336 MemRCol1436 1000.000000
R31337 MemRCol1337 MemRCol1437 1000.000000
R31338 MemRCol1338 MemRCol1438 1000.000000
R31339 MemRCol1339 MemRCol1439 1000.000000
R31340 MemRCol1340 MemRCol1440 1000.000000
R31341 MemRCol1341 MemRCol1441 1000.000000
R31342 MemRCol1342 MemRCol1442 1000.000000
R31343 MemRCol1343 MemRCol1443 1000.000000
R31344 MemRCol1344 MemRCol1444 1000.000000
R31345 MemRCol1345 MemRCol1445 1000.000000
R31346 MemRCol1346 MemRCol1446 1000.000000
R31347 MemRCol1347 MemRCol1447 1000.000000
R31348 MemRCol1348 MemRCol1448 1000.000000
R31349 MemRCol1349 MemRCol1449 1000.000000
R31350 MemRCol1350 MemRCol1450 1000.000000
R3141 MemRCol141 MemRCol151 1000.000000
R3142 MemRCol142 MemRCol152 1000.000000
R3143 MemRCol143 MemRCol153 1000.000000
R3144 MemRCol144 MemRCol154 1000.000000
R3145 MemRCol145 MemRCol155 1000.000000
R3146 MemRCol146 MemRCol156 1000.000000
R3147 MemRCol147 MemRCol157 1000.000000
R3148 MemRCol148 MemRCol158 1000.000000
R3149 MemRCol149 MemRCol159 1000.000000
R31410 MemRCol1410 MemRCol1510 1000.000000
R31411 MemRCol1411 MemRCol1511 1000.000000
R31412 MemRCol1412 MemRCol1512 1000.000000
R31413 MemRCol1413 MemRCol1513 1000.000000
R31414 MemRCol1414 MemRCol1514 1000.000000
R31415 MemRCol1415 MemRCol1515 1000.000000
R31416 MemRCol1416 MemRCol1516 1000.000000
R31417 MemRCol1417 MemRCol1517 1000.000000
R31418 MemRCol1418 MemRCol1518 1000.000000
R31419 MemRCol1419 MemRCol1519 1000.000000
R31420 MemRCol1420 MemRCol1520 1000.000000
R31421 MemRCol1421 MemRCol1521 1000.000000
R31422 MemRCol1422 MemRCol1522 1000.000000
R31423 MemRCol1423 MemRCol1523 1000.000000
R31424 MemRCol1424 MemRCol1524 1000.000000
R31425 MemRCol1425 MemRCol1525 1000.000000
R31426 MemRCol1426 MemRCol1526 1000.000000
R31427 MemRCol1427 MemRCol1527 1000.000000
R31428 MemRCol1428 MemRCol1528 1000.000000
R31429 MemRCol1429 MemRCol1529 1000.000000
R31430 MemRCol1430 MemRCol1530 1000.000000
R31431 MemRCol1431 MemRCol1531 1000.000000
R31432 MemRCol1432 MemRCol1532 1000.000000
R31433 MemRCol1433 MemRCol1533 1000.000000
R31434 MemRCol1434 MemRCol1534 1000.000000
R31435 MemRCol1435 MemRCol1535 1000.000000
R31436 MemRCol1436 MemRCol1536 1000.000000
R31437 MemRCol1437 MemRCol1537 1000.000000
R31438 MemRCol1438 MemRCol1538 1000.000000
R31439 MemRCol1439 MemRCol1539 1000.000000
R31440 MemRCol1440 MemRCol1540 1000.000000
R31441 MemRCol1441 MemRCol1541 1000.000000
R31442 MemRCol1442 MemRCol1542 1000.000000
R31443 MemRCol1443 MemRCol1543 1000.000000
R31444 MemRCol1444 MemRCol1544 1000.000000
R31445 MemRCol1445 MemRCol1545 1000.000000
R31446 MemRCol1446 MemRCol1546 1000.000000
R31447 MemRCol1447 MemRCol1547 1000.000000
R31448 MemRCol1448 MemRCol1548 1000.000000
R31449 MemRCol1449 MemRCol1549 1000.000000
R31450 MemRCol1450 MemRCol1550 1000.000000
R3151 MemRCol151 MemRCol161 1000.000000
R3152 MemRCol152 MemRCol162 1000.000000
R3153 MemRCol153 MemRCol163 1000.000000
R3154 MemRCol154 MemRCol164 1000.000000
R3155 MemRCol155 MemRCol165 1000.000000
R3156 MemRCol156 MemRCol166 1000.000000
R3157 MemRCol157 MemRCol167 1000.000000
R3158 MemRCol158 MemRCol168 1000.000000
R3159 MemRCol159 MemRCol169 1000.000000
R31510 MemRCol1510 MemRCol1610 1000.000000
R31511 MemRCol1511 MemRCol1611 1000.000000
R31512 MemRCol1512 MemRCol1612 1000.000000
R31513 MemRCol1513 MemRCol1613 1000.000000
R31514 MemRCol1514 MemRCol1614 1000.000000
R31515 MemRCol1515 MemRCol1615 1000.000000
R31516 MemRCol1516 MemRCol1616 1000.000000
R31517 MemRCol1517 MemRCol1617 1000.000000
R31518 MemRCol1518 MemRCol1618 1000.000000
R31519 MemRCol1519 MemRCol1619 1000.000000
R31520 MemRCol1520 MemRCol1620 1000.000000
R31521 MemRCol1521 MemRCol1621 1000.000000
R31522 MemRCol1522 MemRCol1622 1000.000000
R31523 MemRCol1523 MemRCol1623 1000.000000
R31524 MemRCol1524 MemRCol1624 1000.000000
R31525 MemRCol1525 MemRCol1625 1000.000000
R31526 MemRCol1526 MemRCol1626 1000.000000
R31527 MemRCol1527 MemRCol1627 1000.000000
R31528 MemRCol1528 MemRCol1628 1000.000000
R31529 MemRCol1529 MemRCol1629 1000.000000
R31530 MemRCol1530 MemRCol1630 1000.000000
R31531 MemRCol1531 MemRCol1631 1000.000000
R31532 MemRCol1532 MemRCol1632 1000.000000
R31533 MemRCol1533 MemRCol1633 1000.000000
R31534 MemRCol1534 MemRCol1634 1000.000000
R31535 MemRCol1535 MemRCol1635 1000.000000
R31536 MemRCol1536 MemRCol1636 1000.000000
R31537 MemRCol1537 MemRCol1637 1000.000000
R31538 MemRCol1538 MemRCol1638 1000.000000
R31539 MemRCol1539 MemRCol1639 1000.000000
R31540 MemRCol1540 MemRCol1640 1000.000000
R31541 MemRCol1541 MemRCol1641 1000.000000
R31542 MemRCol1542 MemRCol1642 1000.000000
R31543 MemRCol1543 MemRCol1643 1000.000000
R31544 MemRCol1544 MemRCol1644 1000.000000
R31545 MemRCol1545 MemRCol1645 1000.000000
R31546 MemRCol1546 MemRCol1646 1000.000000
R31547 MemRCol1547 MemRCol1647 1000.000000
R31548 MemRCol1548 MemRCol1648 1000.000000
R31549 MemRCol1549 MemRCol1649 1000.000000
R31550 MemRCol1550 MemRCol1650 1000.000000
R3161 MemRCol161 MemRCol171 1000.000000
R3162 MemRCol162 MemRCol172 1000.000000
R3163 MemRCol163 MemRCol173 1000.000000
R3164 MemRCol164 MemRCol174 1000.000000
R3165 MemRCol165 MemRCol175 1000.000000
R3166 MemRCol166 MemRCol176 1000.000000
R3167 MemRCol167 MemRCol177 1000.000000
R3168 MemRCol168 MemRCol178 1000.000000
R3169 MemRCol169 MemRCol179 1000.000000
R31610 MemRCol1610 MemRCol1710 1000.000000
R31611 MemRCol1611 MemRCol1711 1000.000000
R31612 MemRCol1612 MemRCol1712 1000.000000
R31613 MemRCol1613 MemRCol1713 1000.000000
R31614 MemRCol1614 MemRCol1714 1000.000000
R31615 MemRCol1615 MemRCol1715 1000.000000
R31616 MemRCol1616 MemRCol1716 1000.000000
R31617 MemRCol1617 MemRCol1717 1000.000000
R31618 MemRCol1618 MemRCol1718 1000.000000
R31619 MemRCol1619 MemRCol1719 1000.000000
R31620 MemRCol1620 MemRCol1720 1000.000000
R31621 MemRCol1621 MemRCol1721 1000.000000
R31622 MemRCol1622 MemRCol1722 1000.000000
R31623 MemRCol1623 MemRCol1723 1000.000000
R31624 MemRCol1624 MemRCol1724 1000.000000
R31625 MemRCol1625 MemRCol1725 1000.000000
R31626 MemRCol1626 MemRCol1726 1000.000000
R31627 MemRCol1627 MemRCol1727 1000.000000
R31628 MemRCol1628 MemRCol1728 1000.000000
R31629 MemRCol1629 MemRCol1729 1000.000000
R31630 MemRCol1630 MemRCol1730 1000.000000
R31631 MemRCol1631 MemRCol1731 1000.000000
R31632 MemRCol1632 MemRCol1732 1000.000000
R31633 MemRCol1633 MemRCol1733 1000.000000
R31634 MemRCol1634 MemRCol1734 1000.000000
R31635 MemRCol1635 MemRCol1735 1000.000000
R31636 MemRCol1636 MemRCol1736 1000.000000
R31637 MemRCol1637 MemRCol1737 1000.000000
R31638 MemRCol1638 MemRCol1738 1000.000000
R31639 MemRCol1639 MemRCol1739 1000.000000
R31640 MemRCol1640 MemRCol1740 1000.000000
R31641 MemRCol1641 MemRCol1741 1000.000000
R31642 MemRCol1642 MemRCol1742 1000.000000
R31643 MemRCol1643 MemRCol1743 1000.000000
R31644 MemRCol1644 MemRCol1744 1000.000000
R31645 MemRCol1645 MemRCol1745 1000.000000
R31646 MemRCol1646 MemRCol1746 1000.000000
R31647 MemRCol1647 MemRCol1747 1000.000000
R31648 MemRCol1648 MemRCol1748 1000.000000
R31649 MemRCol1649 MemRCol1749 1000.000000
R31650 MemRCol1650 MemRCol1750 1000.000000
R3171 MemRCol171 MemRCol181 1000.000000
R3172 MemRCol172 MemRCol182 1000.000000
R3173 MemRCol173 MemRCol183 1000.000000
R3174 MemRCol174 MemRCol184 1000.000000
R3175 MemRCol175 MemRCol185 1000.000000
R3176 MemRCol176 MemRCol186 1000.000000
R3177 MemRCol177 MemRCol187 1000.000000
R3178 MemRCol178 MemRCol188 1000.000000
R3179 MemRCol179 MemRCol189 1000.000000
R31710 MemRCol1710 MemRCol1810 1000.000000
R31711 MemRCol1711 MemRCol1811 1000.000000
R31712 MemRCol1712 MemRCol1812 1000.000000
R31713 MemRCol1713 MemRCol1813 1000.000000
R31714 MemRCol1714 MemRCol1814 1000.000000
R31715 MemRCol1715 MemRCol1815 1000.000000
R31716 MemRCol1716 MemRCol1816 1000.000000
R31717 MemRCol1717 MemRCol1817 1000.000000
R31718 MemRCol1718 MemRCol1818 1000.000000
R31719 MemRCol1719 MemRCol1819 1000.000000
R31720 MemRCol1720 MemRCol1820 1000.000000
R31721 MemRCol1721 MemRCol1821 1000.000000
R31722 MemRCol1722 MemRCol1822 1000.000000
R31723 MemRCol1723 MemRCol1823 1000.000000
R31724 MemRCol1724 MemRCol1824 1000.000000
R31725 MemRCol1725 MemRCol1825 1000.000000
R31726 MemRCol1726 MemRCol1826 1000.000000
R31727 MemRCol1727 MemRCol1827 1000.000000
R31728 MemRCol1728 MemRCol1828 1000.000000
R31729 MemRCol1729 MemRCol1829 1000.000000
R31730 MemRCol1730 MemRCol1830 1000.000000
R31731 MemRCol1731 MemRCol1831 1000.000000
R31732 MemRCol1732 MemRCol1832 1000.000000
R31733 MemRCol1733 MemRCol1833 1000.000000
R31734 MemRCol1734 MemRCol1834 1000.000000
R31735 MemRCol1735 MemRCol1835 1000.000000
R31736 MemRCol1736 MemRCol1836 1000.000000
R31737 MemRCol1737 MemRCol1837 1000.000000
R31738 MemRCol1738 MemRCol1838 1000.000000
R31739 MemRCol1739 MemRCol1839 1000.000000
R31740 MemRCol1740 MemRCol1840 1000.000000
R31741 MemRCol1741 MemRCol1841 1000.000000
R31742 MemRCol1742 MemRCol1842 1000.000000
R31743 MemRCol1743 MemRCol1843 1000.000000
R31744 MemRCol1744 MemRCol1844 1000.000000
R31745 MemRCol1745 MemRCol1845 1000.000000
R31746 MemRCol1746 MemRCol1846 1000.000000
R31747 MemRCol1747 MemRCol1847 1000.000000
R31748 MemRCol1748 MemRCol1848 1000.000000
R31749 MemRCol1749 MemRCol1849 1000.000000
R31750 MemRCol1750 MemRCol1850 1000.000000
R3181 MemRCol181 MemRCol191 1000.000000
R3182 MemRCol182 MemRCol192 1000.000000
R3183 MemRCol183 MemRCol193 1000.000000
R3184 MemRCol184 MemRCol194 1000.000000
R3185 MemRCol185 MemRCol195 1000.000000
R3186 MemRCol186 MemRCol196 1000.000000
R3187 MemRCol187 MemRCol197 1000.000000
R3188 MemRCol188 MemRCol198 1000.000000
R3189 MemRCol189 MemRCol199 1000.000000
R31810 MemRCol1810 MemRCol1910 1000.000000
R31811 MemRCol1811 MemRCol1911 1000.000000
R31812 MemRCol1812 MemRCol1912 1000.000000
R31813 MemRCol1813 MemRCol1913 1000.000000
R31814 MemRCol1814 MemRCol1914 1000.000000
R31815 MemRCol1815 MemRCol1915 1000.000000
R31816 MemRCol1816 MemRCol1916 1000.000000
R31817 MemRCol1817 MemRCol1917 1000.000000
R31818 MemRCol1818 MemRCol1918 1000.000000
R31819 MemRCol1819 MemRCol1919 1000.000000
R31820 MemRCol1820 MemRCol1920 1000.000000
R31821 MemRCol1821 MemRCol1921 1000.000000
R31822 MemRCol1822 MemRCol1922 1000.000000
R31823 MemRCol1823 MemRCol1923 1000.000000
R31824 MemRCol1824 MemRCol1924 1000.000000
R31825 MemRCol1825 MemRCol1925 1000.000000
R31826 MemRCol1826 MemRCol1926 1000.000000
R31827 MemRCol1827 MemRCol1927 1000.000000
R31828 MemRCol1828 MemRCol1928 1000.000000
R31829 MemRCol1829 MemRCol1929 1000.000000
R31830 MemRCol1830 MemRCol1930 1000.000000
R31831 MemRCol1831 MemRCol1931 1000.000000
R31832 MemRCol1832 MemRCol1932 1000.000000
R31833 MemRCol1833 MemRCol1933 1000.000000
R31834 MemRCol1834 MemRCol1934 1000.000000
R31835 MemRCol1835 MemRCol1935 1000.000000
R31836 MemRCol1836 MemRCol1936 1000.000000
R31837 MemRCol1837 MemRCol1937 1000.000000
R31838 MemRCol1838 MemRCol1938 1000.000000
R31839 MemRCol1839 MemRCol1939 1000.000000
R31840 MemRCol1840 MemRCol1940 1000.000000
R31841 MemRCol1841 MemRCol1941 1000.000000
R31842 MemRCol1842 MemRCol1942 1000.000000
R31843 MemRCol1843 MemRCol1943 1000.000000
R31844 MemRCol1844 MemRCol1944 1000.000000
R31845 MemRCol1845 MemRCol1945 1000.000000
R31846 MemRCol1846 MemRCol1946 1000.000000
R31847 MemRCol1847 MemRCol1947 1000.000000
R31848 MemRCol1848 MemRCol1948 1000.000000
R31849 MemRCol1849 MemRCol1949 1000.000000
R31850 MemRCol1850 MemRCol1950 1000.000000
R3191 MemRCol191 MemRCol201 1000.000000
R3192 MemRCol192 MemRCol202 1000.000000
R3193 MemRCol193 MemRCol203 1000.000000
R3194 MemRCol194 MemRCol204 1000.000000
R3195 MemRCol195 MemRCol205 1000.000000
R3196 MemRCol196 MemRCol206 1000.000000
R3197 MemRCol197 MemRCol207 1000.000000
R3198 MemRCol198 MemRCol208 1000.000000
R3199 MemRCol199 MemRCol209 1000.000000
R31910 MemRCol1910 MemRCol2010 1000.000000
R31911 MemRCol1911 MemRCol2011 1000.000000
R31912 MemRCol1912 MemRCol2012 1000.000000
R31913 MemRCol1913 MemRCol2013 1000.000000
R31914 MemRCol1914 MemRCol2014 1000.000000
R31915 MemRCol1915 MemRCol2015 1000.000000
R31916 MemRCol1916 MemRCol2016 1000.000000
R31917 MemRCol1917 MemRCol2017 1000.000000
R31918 MemRCol1918 MemRCol2018 1000.000000
R31919 MemRCol1919 MemRCol2019 1000.000000
R31920 MemRCol1920 MemRCol2020 1000.000000
R31921 MemRCol1921 MemRCol2021 1000.000000
R31922 MemRCol1922 MemRCol2022 1000.000000
R31923 MemRCol1923 MemRCol2023 1000.000000
R31924 MemRCol1924 MemRCol2024 1000.000000
R31925 MemRCol1925 MemRCol2025 1000.000000
R31926 MemRCol1926 MemRCol2026 1000.000000
R31927 MemRCol1927 MemRCol2027 1000.000000
R31928 MemRCol1928 MemRCol2028 1000.000000
R31929 MemRCol1929 MemRCol2029 1000.000000
R31930 MemRCol1930 MemRCol2030 1000.000000
R31931 MemRCol1931 MemRCol2031 1000.000000
R31932 MemRCol1932 MemRCol2032 1000.000000
R31933 MemRCol1933 MemRCol2033 1000.000000
R31934 MemRCol1934 MemRCol2034 1000.000000
R31935 MemRCol1935 MemRCol2035 1000.000000
R31936 MemRCol1936 MemRCol2036 1000.000000
R31937 MemRCol1937 MemRCol2037 1000.000000
R31938 MemRCol1938 MemRCol2038 1000.000000
R31939 MemRCol1939 MemRCol2039 1000.000000
R31940 MemRCol1940 MemRCol2040 1000.000000
R31941 MemRCol1941 MemRCol2041 1000.000000
R31942 MemRCol1942 MemRCol2042 1000.000000
R31943 MemRCol1943 MemRCol2043 1000.000000
R31944 MemRCol1944 MemRCol2044 1000.000000
R31945 MemRCol1945 MemRCol2045 1000.000000
R31946 MemRCol1946 MemRCol2046 1000.000000
R31947 MemRCol1947 MemRCol2047 1000.000000
R31948 MemRCol1948 MemRCol2048 1000.000000
R31949 MemRCol1949 MemRCol2049 1000.000000
R31950 MemRCol1950 MemRCol2050 1000.000000
R3201 MemRCol201 MemRCol211 1000.000000
R3202 MemRCol202 MemRCol212 1000.000000
R3203 MemRCol203 MemRCol213 1000.000000
R3204 MemRCol204 MemRCol214 1000.000000
R3205 MemRCol205 MemRCol215 1000.000000
R3206 MemRCol206 MemRCol216 1000.000000
R3207 MemRCol207 MemRCol217 1000.000000
R3208 MemRCol208 MemRCol218 1000.000000
R3209 MemRCol209 MemRCol219 1000.000000
R32010 MemRCol2010 MemRCol2110 1000.000000
R32011 MemRCol2011 MemRCol2111 1000.000000
R32012 MemRCol2012 MemRCol2112 1000.000000
R32013 MemRCol2013 MemRCol2113 1000.000000
R32014 MemRCol2014 MemRCol2114 1000.000000
R32015 MemRCol2015 MemRCol2115 1000.000000
R32016 MemRCol2016 MemRCol2116 1000.000000
R32017 MemRCol2017 MemRCol2117 1000.000000
R32018 MemRCol2018 MemRCol2118 1000.000000
R32019 MemRCol2019 MemRCol2119 1000.000000
R32020 MemRCol2020 MemRCol2120 1000.000000
R32021 MemRCol2021 MemRCol2121 1000.000000
R32022 MemRCol2022 MemRCol2122 1000.000000
R32023 MemRCol2023 MemRCol2123 1000.000000
R32024 MemRCol2024 MemRCol2124 1000.000000
R32025 MemRCol2025 MemRCol2125 1000.000000
R32026 MemRCol2026 MemRCol2126 1000.000000
R32027 MemRCol2027 MemRCol2127 1000.000000
R32028 MemRCol2028 MemRCol2128 1000.000000
R32029 MemRCol2029 MemRCol2129 1000.000000
R32030 MemRCol2030 MemRCol2130 1000.000000
R32031 MemRCol2031 MemRCol2131 1000.000000
R32032 MemRCol2032 MemRCol2132 1000.000000
R32033 MemRCol2033 MemRCol2133 1000.000000
R32034 MemRCol2034 MemRCol2134 1000.000000
R32035 MemRCol2035 MemRCol2135 1000.000000
R32036 MemRCol2036 MemRCol2136 1000.000000
R32037 MemRCol2037 MemRCol2137 1000.000000
R32038 MemRCol2038 MemRCol2138 1000.000000
R32039 MemRCol2039 MemRCol2139 1000.000000
R32040 MemRCol2040 MemRCol2140 1000.000000
R32041 MemRCol2041 MemRCol2141 1000.000000
R32042 MemRCol2042 MemRCol2142 1000.000000
R32043 MemRCol2043 MemRCol2143 1000.000000
R32044 MemRCol2044 MemRCol2144 1000.000000
R32045 MemRCol2045 MemRCol2145 1000.000000
R32046 MemRCol2046 MemRCol2146 1000.000000
R32047 MemRCol2047 MemRCol2147 1000.000000
R32048 MemRCol2048 MemRCol2148 1000.000000
R32049 MemRCol2049 MemRCol2149 1000.000000
R32050 MemRCol2050 MemRCol2150 1000.000000
R3211 MemRCol211 MemRCol221 1000.000000
R3212 MemRCol212 MemRCol222 1000.000000
R3213 MemRCol213 MemRCol223 1000.000000
R3214 MemRCol214 MemRCol224 1000.000000
R3215 MemRCol215 MemRCol225 1000.000000
R3216 MemRCol216 MemRCol226 1000.000000
R3217 MemRCol217 MemRCol227 1000.000000
R3218 MemRCol218 MemRCol228 1000.000000
R3219 MemRCol219 MemRCol229 1000.000000
R32110 MemRCol2110 MemRCol2210 1000.000000
R32111 MemRCol2111 MemRCol2211 1000.000000
R32112 MemRCol2112 MemRCol2212 1000.000000
R32113 MemRCol2113 MemRCol2213 1000.000000
R32114 MemRCol2114 MemRCol2214 1000.000000
R32115 MemRCol2115 MemRCol2215 1000.000000
R32116 MemRCol2116 MemRCol2216 1000.000000
R32117 MemRCol2117 MemRCol2217 1000.000000
R32118 MemRCol2118 MemRCol2218 1000.000000
R32119 MemRCol2119 MemRCol2219 1000.000000
R32120 MemRCol2120 MemRCol2220 1000.000000
R32121 MemRCol2121 MemRCol2221 1000.000000
R32122 MemRCol2122 MemRCol2222 1000.000000
R32123 MemRCol2123 MemRCol2223 1000.000000
R32124 MemRCol2124 MemRCol2224 1000.000000
R32125 MemRCol2125 MemRCol2225 1000.000000
R32126 MemRCol2126 MemRCol2226 1000.000000
R32127 MemRCol2127 MemRCol2227 1000.000000
R32128 MemRCol2128 MemRCol2228 1000.000000
R32129 MemRCol2129 MemRCol2229 1000.000000
R32130 MemRCol2130 MemRCol2230 1000.000000
R32131 MemRCol2131 MemRCol2231 1000.000000
R32132 MemRCol2132 MemRCol2232 1000.000000
R32133 MemRCol2133 MemRCol2233 1000.000000
R32134 MemRCol2134 MemRCol2234 1000.000000
R32135 MemRCol2135 MemRCol2235 1000.000000
R32136 MemRCol2136 MemRCol2236 1000.000000
R32137 MemRCol2137 MemRCol2237 1000.000000
R32138 MemRCol2138 MemRCol2238 1000.000000
R32139 MemRCol2139 MemRCol2239 1000.000000
R32140 MemRCol2140 MemRCol2240 1000.000000
R32141 MemRCol2141 MemRCol2241 1000.000000
R32142 MemRCol2142 MemRCol2242 1000.000000
R32143 MemRCol2143 MemRCol2243 1000.000000
R32144 MemRCol2144 MemRCol2244 1000.000000
R32145 MemRCol2145 MemRCol2245 1000.000000
R32146 MemRCol2146 MemRCol2246 1000.000000
R32147 MemRCol2147 MemRCol2247 1000.000000
R32148 MemRCol2148 MemRCol2248 1000.000000
R32149 MemRCol2149 MemRCol2249 1000.000000
R32150 MemRCol2150 MemRCol2250 1000.000000
R3221 MemRCol221 MemRCol231 1000.000000
R3222 MemRCol222 MemRCol232 1000.000000
R3223 MemRCol223 MemRCol233 1000.000000
R3224 MemRCol224 MemRCol234 1000.000000
R3225 MemRCol225 MemRCol235 1000.000000
R3226 MemRCol226 MemRCol236 1000.000000
R3227 MemRCol227 MemRCol237 1000.000000
R3228 MemRCol228 MemRCol238 1000.000000
R3229 MemRCol229 MemRCol239 1000.000000
R32210 MemRCol2210 MemRCol2310 1000.000000
R32211 MemRCol2211 MemRCol2311 1000.000000
R32212 MemRCol2212 MemRCol2312 1000.000000
R32213 MemRCol2213 MemRCol2313 1000.000000
R32214 MemRCol2214 MemRCol2314 1000.000000
R32215 MemRCol2215 MemRCol2315 1000.000000
R32216 MemRCol2216 MemRCol2316 1000.000000
R32217 MemRCol2217 MemRCol2317 1000.000000
R32218 MemRCol2218 MemRCol2318 1000.000000
R32219 MemRCol2219 MemRCol2319 1000.000000
R32220 MemRCol2220 MemRCol2320 1000.000000
R32221 MemRCol2221 MemRCol2321 1000.000000
R32222 MemRCol2222 MemRCol2322 1000.000000
R32223 MemRCol2223 MemRCol2323 1000.000000
R32224 MemRCol2224 MemRCol2324 1000.000000
R32225 MemRCol2225 MemRCol2325 1000.000000
R32226 MemRCol2226 MemRCol2326 1000.000000
R32227 MemRCol2227 MemRCol2327 1000.000000
R32228 MemRCol2228 MemRCol2328 1000.000000
R32229 MemRCol2229 MemRCol2329 1000.000000
R32230 MemRCol2230 MemRCol2330 1000.000000
R32231 MemRCol2231 MemRCol2331 1000.000000
R32232 MemRCol2232 MemRCol2332 1000.000000
R32233 MemRCol2233 MemRCol2333 1000.000000
R32234 MemRCol2234 MemRCol2334 1000.000000
R32235 MemRCol2235 MemRCol2335 1000.000000
R32236 MemRCol2236 MemRCol2336 1000.000000
R32237 MemRCol2237 MemRCol2337 1000.000000
R32238 MemRCol2238 MemRCol2338 1000.000000
R32239 MemRCol2239 MemRCol2339 1000.000000
R32240 MemRCol2240 MemRCol2340 1000.000000
R32241 MemRCol2241 MemRCol2341 1000.000000
R32242 MemRCol2242 MemRCol2342 1000.000000
R32243 MemRCol2243 MemRCol2343 1000.000000
R32244 MemRCol2244 MemRCol2344 1000.000000
R32245 MemRCol2245 MemRCol2345 1000.000000
R32246 MemRCol2246 MemRCol2346 1000.000000
R32247 MemRCol2247 MemRCol2347 1000.000000
R32248 MemRCol2248 MemRCol2348 1000.000000
R32249 MemRCol2249 MemRCol2349 1000.000000
R32250 MemRCol2250 MemRCol2350 1000.000000
R3231 MemRCol231 MemRCol241 1000.000000
R3232 MemRCol232 MemRCol242 1000.000000
R3233 MemRCol233 MemRCol243 1000.000000
R3234 MemRCol234 MemRCol244 1000.000000
R3235 MemRCol235 MemRCol245 1000.000000
R3236 MemRCol236 MemRCol246 1000.000000
R3237 MemRCol237 MemRCol247 1000.000000
R3238 MemRCol238 MemRCol248 1000.000000
R3239 MemRCol239 MemRCol249 1000.000000
R32310 MemRCol2310 MemRCol2410 1000.000000
R32311 MemRCol2311 MemRCol2411 1000.000000
R32312 MemRCol2312 MemRCol2412 1000.000000
R32313 MemRCol2313 MemRCol2413 1000.000000
R32314 MemRCol2314 MemRCol2414 1000.000000
R32315 MemRCol2315 MemRCol2415 1000.000000
R32316 MemRCol2316 MemRCol2416 1000.000000
R32317 MemRCol2317 MemRCol2417 1000.000000
R32318 MemRCol2318 MemRCol2418 1000.000000
R32319 MemRCol2319 MemRCol2419 1000.000000
R32320 MemRCol2320 MemRCol2420 1000.000000
R32321 MemRCol2321 MemRCol2421 1000.000000
R32322 MemRCol2322 MemRCol2422 1000.000000
R32323 MemRCol2323 MemRCol2423 1000.000000
R32324 MemRCol2324 MemRCol2424 1000.000000
R32325 MemRCol2325 MemRCol2425 1000.000000
R32326 MemRCol2326 MemRCol2426 1000.000000
R32327 MemRCol2327 MemRCol2427 1000.000000
R32328 MemRCol2328 MemRCol2428 1000.000000
R32329 MemRCol2329 MemRCol2429 1000.000000
R32330 MemRCol2330 MemRCol2430 1000.000000
R32331 MemRCol2331 MemRCol2431 1000.000000
R32332 MemRCol2332 MemRCol2432 1000.000000
R32333 MemRCol2333 MemRCol2433 1000.000000
R32334 MemRCol2334 MemRCol2434 1000.000000
R32335 MemRCol2335 MemRCol2435 1000.000000
R32336 MemRCol2336 MemRCol2436 1000.000000
R32337 MemRCol2337 MemRCol2437 1000.000000
R32338 MemRCol2338 MemRCol2438 1000.000000
R32339 MemRCol2339 MemRCol2439 1000.000000
R32340 MemRCol2340 MemRCol2440 1000.000000
R32341 MemRCol2341 MemRCol2441 1000.000000
R32342 MemRCol2342 MemRCol2442 1000.000000
R32343 MemRCol2343 MemRCol2443 1000.000000
R32344 MemRCol2344 MemRCol2444 1000.000000
R32345 MemRCol2345 MemRCol2445 1000.000000
R32346 MemRCol2346 MemRCol2446 1000.000000
R32347 MemRCol2347 MemRCol2447 1000.000000
R32348 MemRCol2348 MemRCol2448 1000.000000
R32349 MemRCol2349 MemRCol2449 1000.000000
R32350 MemRCol2350 MemRCol2450 1000.000000
R3241 MemRCol241 MemRCol251 1000.000000
R3242 MemRCol242 MemRCol252 1000.000000
R3243 MemRCol243 MemRCol253 1000.000000
R3244 MemRCol244 MemRCol254 1000.000000
R3245 MemRCol245 MemRCol255 1000.000000
R3246 MemRCol246 MemRCol256 1000.000000
R3247 MemRCol247 MemRCol257 1000.000000
R3248 MemRCol248 MemRCol258 1000.000000
R3249 MemRCol249 MemRCol259 1000.000000
R32410 MemRCol2410 MemRCol2510 1000.000000
R32411 MemRCol2411 MemRCol2511 1000.000000
R32412 MemRCol2412 MemRCol2512 1000.000000
R32413 MemRCol2413 MemRCol2513 1000.000000
R32414 MemRCol2414 MemRCol2514 1000.000000
R32415 MemRCol2415 MemRCol2515 1000.000000
R32416 MemRCol2416 MemRCol2516 1000.000000
R32417 MemRCol2417 MemRCol2517 1000.000000
R32418 MemRCol2418 MemRCol2518 1000.000000
R32419 MemRCol2419 MemRCol2519 1000.000000
R32420 MemRCol2420 MemRCol2520 1000.000000
R32421 MemRCol2421 MemRCol2521 1000.000000
R32422 MemRCol2422 MemRCol2522 1000.000000
R32423 MemRCol2423 MemRCol2523 1000.000000
R32424 MemRCol2424 MemRCol2524 1000.000000
R32425 MemRCol2425 MemRCol2525 1000.000000
R32426 MemRCol2426 MemRCol2526 1000.000000
R32427 MemRCol2427 MemRCol2527 1000.000000
R32428 MemRCol2428 MemRCol2528 1000.000000
R32429 MemRCol2429 MemRCol2529 1000.000000
R32430 MemRCol2430 MemRCol2530 1000.000000
R32431 MemRCol2431 MemRCol2531 1000.000000
R32432 MemRCol2432 MemRCol2532 1000.000000
R32433 MemRCol2433 MemRCol2533 1000.000000
R32434 MemRCol2434 MemRCol2534 1000.000000
R32435 MemRCol2435 MemRCol2535 1000.000000
R32436 MemRCol2436 MemRCol2536 1000.000000
R32437 MemRCol2437 MemRCol2537 1000.000000
R32438 MemRCol2438 MemRCol2538 1000.000000
R32439 MemRCol2439 MemRCol2539 1000.000000
R32440 MemRCol2440 MemRCol2540 1000.000000
R32441 MemRCol2441 MemRCol2541 1000.000000
R32442 MemRCol2442 MemRCol2542 1000.000000
R32443 MemRCol2443 MemRCol2543 1000.000000
R32444 MemRCol2444 MemRCol2544 1000.000000
R32445 MemRCol2445 MemRCol2545 1000.000000
R32446 MemRCol2446 MemRCol2546 1000.000000
R32447 MemRCol2447 MemRCol2547 1000.000000
R32448 MemRCol2448 MemRCol2548 1000.000000
R32449 MemRCol2449 MemRCol2549 1000.000000
R32450 MemRCol2450 MemRCol2550 1000.000000
R3251 MemRCol251 MemRCol261 1000.000000
R3252 MemRCol252 MemRCol262 1000.000000
R3253 MemRCol253 MemRCol263 1000.000000
R3254 MemRCol254 MemRCol264 1000.000000
R3255 MemRCol255 MemRCol265 1000.000000
R3256 MemRCol256 MemRCol266 1000.000000
R3257 MemRCol257 MemRCol267 1000.000000
R3258 MemRCol258 MemRCol268 1000.000000
R3259 MemRCol259 MemRCol269 1000.000000
R32510 MemRCol2510 MemRCol2610 1000.000000
R32511 MemRCol2511 MemRCol2611 1000.000000
R32512 MemRCol2512 MemRCol2612 1000.000000
R32513 MemRCol2513 MemRCol2613 1000.000000
R32514 MemRCol2514 MemRCol2614 1000.000000
R32515 MemRCol2515 MemRCol2615 1000.000000
R32516 MemRCol2516 MemRCol2616 1000.000000
R32517 MemRCol2517 MemRCol2617 1000.000000
R32518 MemRCol2518 MemRCol2618 1000.000000
R32519 MemRCol2519 MemRCol2619 1000.000000
R32520 MemRCol2520 MemRCol2620 1000.000000
R32521 MemRCol2521 MemRCol2621 1000.000000
R32522 MemRCol2522 MemRCol2622 1000.000000
R32523 MemRCol2523 MemRCol2623 1000.000000
R32524 MemRCol2524 MemRCol2624 1000.000000
R32525 MemRCol2525 MemRCol2625 1000.000000
R32526 MemRCol2526 MemRCol2626 1000.000000
R32527 MemRCol2527 MemRCol2627 1000.000000
R32528 MemRCol2528 MemRCol2628 1000.000000
R32529 MemRCol2529 MemRCol2629 1000.000000
R32530 MemRCol2530 MemRCol2630 1000.000000
R32531 MemRCol2531 MemRCol2631 1000.000000
R32532 MemRCol2532 MemRCol2632 1000.000000
R32533 MemRCol2533 MemRCol2633 1000.000000
R32534 MemRCol2534 MemRCol2634 1000.000000
R32535 MemRCol2535 MemRCol2635 1000.000000
R32536 MemRCol2536 MemRCol2636 1000.000000
R32537 MemRCol2537 MemRCol2637 1000.000000
R32538 MemRCol2538 MemRCol2638 1000.000000
R32539 MemRCol2539 MemRCol2639 1000.000000
R32540 MemRCol2540 MemRCol2640 1000.000000
R32541 MemRCol2541 MemRCol2641 1000.000000
R32542 MemRCol2542 MemRCol2642 1000.000000
R32543 MemRCol2543 MemRCol2643 1000.000000
R32544 MemRCol2544 MemRCol2644 1000.000000
R32545 MemRCol2545 MemRCol2645 1000.000000
R32546 MemRCol2546 MemRCol2646 1000.000000
R32547 MemRCol2547 MemRCol2647 1000.000000
R32548 MemRCol2548 MemRCol2648 1000.000000
R32549 MemRCol2549 MemRCol2649 1000.000000
R32550 MemRCol2550 MemRCol2650 1000.000000
R3261 MemRCol261 MemRCol271 1000.000000
R3262 MemRCol262 MemRCol272 1000.000000
R3263 MemRCol263 MemRCol273 1000.000000
R3264 MemRCol264 MemRCol274 1000.000000
R3265 MemRCol265 MemRCol275 1000.000000
R3266 MemRCol266 MemRCol276 1000.000000
R3267 MemRCol267 MemRCol277 1000.000000
R3268 MemRCol268 MemRCol278 1000.000000
R3269 MemRCol269 MemRCol279 1000.000000
R32610 MemRCol2610 MemRCol2710 1000.000000
R32611 MemRCol2611 MemRCol2711 1000.000000
R32612 MemRCol2612 MemRCol2712 1000.000000
R32613 MemRCol2613 MemRCol2713 1000.000000
R32614 MemRCol2614 MemRCol2714 1000.000000
R32615 MemRCol2615 MemRCol2715 1000.000000
R32616 MemRCol2616 MemRCol2716 1000.000000
R32617 MemRCol2617 MemRCol2717 1000.000000
R32618 MemRCol2618 MemRCol2718 1000.000000
R32619 MemRCol2619 MemRCol2719 1000.000000
R32620 MemRCol2620 MemRCol2720 1000.000000
R32621 MemRCol2621 MemRCol2721 1000.000000
R32622 MemRCol2622 MemRCol2722 1000.000000
R32623 MemRCol2623 MemRCol2723 1000.000000
R32624 MemRCol2624 MemRCol2724 1000.000000
R32625 MemRCol2625 MemRCol2725 1000.000000
R32626 MemRCol2626 MemRCol2726 1000.000000
R32627 MemRCol2627 MemRCol2727 1000.000000
R32628 MemRCol2628 MemRCol2728 1000.000000
R32629 MemRCol2629 MemRCol2729 1000.000000
R32630 MemRCol2630 MemRCol2730 1000.000000
R32631 MemRCol2631 MemRCol2731 1000.000000
R32632 MemRCol2632 MemRCol2732 1000.000000
R32633 MemRCol2633 MemRCol2733 1000.000000
R32634 MemRCol2634 MemRCol2734 1000.000000
R32635 MemRCol2635 MemRCol2735 1000.000000
R32636 MemRCol2636 MemRCol2736 1000.000000
R32637 MemRCol2637 MemRCol2737 1000.000000
R32638 MemRCol2638 MemRCol2738 1000.000000
R32639 MemRCol2639 MemRCol2739 1000.000000
R32640 MemRCol2640 MemRCol2740 1000.000000
R32641 MemRCol2641 MemRCol2741 1000.000000
R32642 MemRCol2642 MemRCol2742 1000.000000
R32643 MemRCol2643 MemRCol2743 1000.000000
R32644 MemRCol2644 MemRCol2744 1000.000000
R32645 MemRCol2645 MemRCol2745 1000.000000
R32646 MemRCol2646 MemRCol2746 1000.000000
R32647 MemRCol2647 MemRCol2747 1000.000000
R32648 MemRCol2648 MemRCol2748 1000.000000
R32649 MemRCol2649 MemRCol2749 1000.000000
R32650 MemRCol2650 MemRCol2750 1000.000000
R3271 MemRCol271 MemRCol281 1000.000000
R3272 MemRCol272 MemRCol282 1000.000000
R3273 MemRCol273 MemRCol283 1000.000000
R3274 MemRCol274 MemRCol284 1000.000000
R3275 MemRCol275 MemRCol285 1000.000000
R3276 MemRCol276 MemRCol286 1000.000000
R3277 MemRCol277 MemRCol287 1000.000000
R3278 MemRCol278 MemRCol288 1000.000000
R3279 MemRCol279 MemRCol289 1000.000000
R32710 MemRCol2710 MemRCol2810 1000.000000
R32711 MemRCol2711 MemRCol2811 1000.000000
R32712 MemRCol2712 MemRCol2812 1000.000000
R32713 MemRCol2713 MemRCol2813 1000.000000
R32714 MemRCol2714 MemRCol2814 1000.000000
R32715 MemRCol2715 MemRCol2815 1000.000000
R32716 MemRCol2716 MemRCol2816 1000.000000
R32717 MemRCol2717 MemRCol2817 1000.000000
R32718 MemRCol2718 MemRCol2818 1000.000000
R32719 MemRCol2719 MemRCol2819 1000.000000
R32720 MemRCol2720 MemRCol2820 1000.000000
R32721 MemRCol2721 MemRCol2821 1000.000000
R32722 MemRCol2722 MemRCol2822 1000.000000
R32723 MemRCol2723 MemRCol2823 1000.000000
R32724 MemRCol2724 MemRCol2824 1000.000000
R32725 MemRCol2725 MemRCol2825 1000.000000
R32726 MemRCol2726 MemRCol2826 1000.000000
R32727 MemRCol2727 MemRCol2827 1000.000000
R32728 MemRCol2728 MemRCol2828 1000.000000
R32729 MemRCol2729 MemRCol2829 1000.000000
R32730 MemRCol2730 MemRCol2830 1000.000000
R32731 MemRCol2731 MemRCol2831 1000.000000
R32732 MemRCol2732 MemRCol2832 1000.000000
R32733 MemRCol2733 MemRCol2833 1000.000000
R32734 MemRCol2734 MemRCol2834 1000.000000
R32735 MemRCol2735 MemRCol2835 1000.000000
R32736 MemRCol2736 MemRCol2836 1000.000000
R32737 MemRCol2737 MemRCol2837 1000.000000
R32738 MemRCol2738 MemRCol2838 1000.000000
R32739 MemRCol2739 MemRCol2839 1000.000000
R32740 MemRCol2740 MemRCol2840 1000.000000
R32741 MemRCol2741 MemRCol2841 1000.000000
R32742 MemRCol2742 MemRCol2842 1000.000000
R32743 MemRCol2743 MemRCol2843 1000.000000
R32744 MemRCol2744 MemRCol2844 1000.000000
R32745 MemRCol2745 MemRCol2845 1000.000000
R32746 MemRCol2746 MemRCol2846 1000.000000
R32747 MemRCol2747 MemRCol2847 1000.000000
R32748 MemRCol2748 MemRCol2848 1000.000000
R32749 MemRCol2749 MemRCol2849 1000.000000
R32750 MemRCol2750 MemRCol2850 1000.000000
R3281 MemRCol281 MemRCol291 1000.000000
R3282 MemRCol282 MemRCol292 1000.000000
R3283 MemRCol283 MemRCol293 1000.000000
R3284 MemRCol284 MemRCol294 1000.000000
R3285 MemRCol285 MemRCol295 1000.000000
R3286 MemRCol286 MemRCol296 1000.000000
R3287 MemRCol287 MemRCol297 1000.000000
R3288 MemRCol288 MemRCol298 1000.000000
R3289 MemRCol289 MemRCol299 1000.000000
R32810 MemRCol2810 MemRCol2910 1000.000000
R32811 MemRCol2811 MemRCol2911 1000.000000
R32812 MemRCol2812 MemRCol2912 1000.000000
R32813 MemRCol2813 MemRCol2913 1000.000000
R32814 MemRCol2814 MemRCol2914 1000.000000
R32815 MemRCol2815 MemRCol2915 1000.000000
R32816 MemRCol2816 MemRCol2916 1000.000000
R32817 MemRCol2817 MemRCol2917 1000.000000
R32818 MemRCol2818 MemRCol2918 1000.000000
R32819 MemRCol2819 MemRCol2919 1000.000000
R32820 MemRCol2820 MemRCol2920 1000.000000
R32821 MemRCol2821 MemRCol2921 1000.000000
R32822 MemRCol2822 MemRCol2922 1000.000000
R32823 MemRCol2823 MemRCol2923 1000.000000
R32824 MemRCol2824 MemRCol2924 1000.000000
R32825 MemRCol2825 MemRCol2925 1000.000000
R32826 MemRCol2826 MemRCol2926 1000.000000
R32827 MemRCol2827 MemRCol2927 1000.000000
R32828 MemRCol2828 MemRCol2928 1000.000000
R32829 MemRCol2829 MemRCol2929 1000.000000
R32830 MemRCol2830 MemRCol2930 1000.000000
R32831 MemRCol2831 MemRCol2931 1000.000000
R32832 MemRCol2832 MemRCol2932 1000.000000
R32833 MemRCol2833 MemRCol2933 1000.000000
R32834 MemRCol2834 MemRCol2934 1000.000000
R32835 MemRCol2835 MemRCol2935 1000.000000
R32836 MemRCol2836 MemRCol2936 1000.000000
R32837 MemRCol2837 MemRCol2937 1000.000000
R32838 MemRCol2838 MemRCol2938 1000.000000
R32839 MemRCol2839 MemRCol2939 1000.000000
R32840 MemRCol2840 MemRCol2940 1000.000000
R32841 MemRCol2841 MemRCol2941 1000.000000
R32842 MemRCol2842 MemRCol2942 1000.000000
R32843 MemRCol2843 MemRCol2943 1000.000000
R32844 MemRCol2844 MemRCol2944 1000.000000
R32845 MemRCol2845 MemRCol2945 1000.000000
R32846 MemRCol2846 MemRCol2946 1000.000000
R32847 MemRCol2847 MemRCol2947 1000.000000
R32848 MemRCol2848 MemRCol2948 1000.000000
R32849 MemRCol2849 MemRCol2949 1000.000000
R32850 MemRCol2850 MemRCol2950 1000.000000
R3291 MemRCol291 MemRCol301 1000.000000
R3292 MemRCol292 MemRCol302 1000.000000
R3293 MemRCol293 MemRCol303 1000.000000
R3294 MemRCol294 MemRCol304 1000.000000
R3295 MemRCol295 MemRCol305 1000.000000
R3296 MemRCol296 MemRCol306 1000.000000
R3297 MemRCol297 MemRCol307 1000.000000
R3298 MemRCol298 MemRCol308 1000.000000
R3299 MemRCol299 MemRCol309 1000.000000
R32910 MemRCol2910 MemRCol3010 1000.000000
R32911 MemRCol2911 MemRCol3011 1000.000000
R32912 MemRCol2912 MemRCol3012 1000.000000
R32913 MemRCol2913 MemRCol3013 1000.000000
R32914 MemRCol2914 MemRCol3014 1000.000000
R32915 MemRCol2915 MemRCol3015 1000.000000
R32916 MemRCol2916 MemRCol3016 1000.000000
R32917 MemRCol2917 MemRCol3017 1000.000000
R32918 MemRCol2918 MemRCol3018 1000.000000
R32919 MemRCol2919 MemRCol3019 1000.000000
R32920 MemRCol2920 MemRCol3020 1000.000000
R32921 MemRCol2921 MemRCol3021 1000.000000
R32922 MemRCol2922 MemRCol3022 1000.000000
R32923 MemRCol2923 MemRCol3023 1000.000000
R32924 MemRCol2924 MemRCol3024 1000.000000
R32925 MemRCol2925 MemRCol3025 1000.000000
R32926 MemRCol2926 MemRCol3026 1000.000000
R32927 MemRCol2927 MemRCol3027 1000.000000
R32928 MemRCol2928 MemRCol3028 1000.000000
R32929 MemRCol2929 MemRCol3029 1000.000000
R32930 MemRCol2930 MemRCol3030 1000.000000
R32931 MemRCol2931 MemRCol3031 1000.000000
R32932 MemRCol2932 MemRCol3032 1000.000000
R32933 MemRCol2933 MemRCol3033 1000.000000
R32934 MemRCol2934 MemRCol3034 1000.000000
R32935 MemRCol2935 MemRCol3035 1000.000000
R32936 MemRCol2936 MemRCol3036 1000.000000
R32937 MemRCol2937 MemRCol3037 1000.000000
R32938 MemRCol2938 MemRCol3038 1000.000000
R32939 MemRCol2939 MemRCol3039 1000.000000
R32940 MemRCol2940 MemRCol3040 1000.000000
R32941 MemRCol2941 MemRCol3041 1000.000000
R32942 MemRCol2942 MemRCol3042 1000.000000
R32943 MemRCol2943 MemRCol3043 1000.000000
R32944 MemRCol2944 MemRCol3044 1000.000000
R32945 MemRCol2945 MemRCol3045 1000.000000
R32946 MemRCol2946 MemRCol3046 1000.000000
R32947 MemRCol2947 MemRCol3047 1000.000000
R32948 MemRCol2948 MemRCol3048 1000.000000
R32949 MemRCol2949 MemRCol3049 1000.000000
R32950 MemRCol2950 MemRCol3050 1000.000000
R3301 MemRCol301 MemRCol311 1000.000000
R3302 MemRCol302 MemRCol312 1000.000000
R3303 MemRCol303 MemRCol313 1000.000000
R3304 MemRCol304 MemRCol314 1000.000000
R3305 MemRCol305 MemRCol315 1000.000000
R3306 MemRCol306 MemRCol316 1000.000000
R3307 MemRCol307 MemRCol317 1000.000000
R3308 MemRCol308 MemRCol318 1000.000000
R3309 MemRCol309 MemRCol319 1000.000000
R33010 MemRCol3010 MemRCol3110 1000.000000
R33011 MemRCol3011 MemRCol3111 1000.000000
R33012 MemRCol3012 MemRCol3112 1000.000000
R33013 MemRCol3013 MemRCol3113 1000.000000
R33014 MemRCol3014 MemRCol3114 1000.000000
R33015 MemRCol3015 MemRCol3115 1000.000000
R33016 MemRCol3016 MemRCol3116 1000.000000
R33017 MemRCol3017 MemRCol3117 1000.000000
R33018 MemRCol3018 MemRCol3118 1000.000000
R33019 MemRCol3019 MemRCol3119 1000.000000
R33020 MemRCol3020 MemRCol3120 1000.000000
R33021 MemRCol3021 MemRCol3121 1000.000000
R33022 MemRCol3022 MemRCol3122 1000.000000
R33023 MemRCol3023 MemRCol3123 1000.000000
R33024 MemRCol3024 MemRCol3124 1000.000000
R33025 MemRCol3025 MemRCol3125 1000.000000
R33026 MemRCol3026 MemRCol3126 1000.000000
R33027 MemRCol3027 MemRCol3127 1000.000000
R33028 MemRCol3028 MemRCol3128 1000.000000
R33029 MemRCol3029 MemRCol3129 1000.000000
R33030 MemRCol3030 MemRCol3130 1000.000000
R33031 MemRCol3031 MemRCol3131 1000.000000
R33032 MemRCol3032 MemRCol3132 1000.000000
R33033 MemRCol3033 MemRCol3133 1000.000000
R33034 MemRCol3034 MemRCol3134 1000.000000
R33035 MemRCol3035 MemRCol3135 1000.000000
R33036 MemRCol3036 MemRCol3136 1000.000000
R33037 MemRCol3037 MemRCol3137 1000.000000
R33038 MemRCol3038 MemRCol3138 1000.000000
R33039 MemRCol3039 MemRCol3139 1000.000000
R33040 MemRCol3040 MemRCol3140 1000.000000
R33041 MemRCol3041 MemRCol3141 1000.000000
R33042 MemRCol3042 MemRCol3142 1000.000000
R33043 MemRCol3043 MemRCol3143 1000.000000
R33044 MemRCol3044 MemRCol3144 1000.000000
R33045 MemRCol3045 MemRCol3145 1000.000000
R33046 MemRCol3046 MemRCol3146 1000.000000
R33047 MemRCol3047 MemRCol3147 1000.000000
R33048 MemRCol3048 MemRCol3148 1000.000000
R33049 MemRCol3049 MemRCol3149 1000.000000
R33050 MemRCol3050 MemRCol3150 1000.000000
R3311 MemRCol311 MemRCol321 1000.000000
R3312 MemRCol312 MemRCol322 1000.000000
R3313 MemRCol313 MemRCol323 1000.000000
R3314 MemRCol314 MemRCol324 1000.000000
R3315 MemRCol315 MemRCol325 1000.000000
R3316 MemRCol316 MemRCol326 1000.000000
R3317 MemRCol317 MemRCol327 1000.000000
R3318 MemRCol318 MemRCol328 1000.000000
R3319 MemRCol319 MemRCol329 1000.000000
R33110 MemRCol3110 MemRCol3210 1000.000000
R33111 MemRCol3111 MemRCol3211 1000.000000
R33112 MemRCol3112 MemRCol3212 1000.000000
R33113 MemRCol3113 MemRCol3213 1000.000000
R33114 MemRCol3114 MemRCol3214 1000.000000
R33115 MemRCol3115 MemRCol3215 1000.000000
R33116 MemRCol3116 MemRCol3216 1000.000000
R33117 MemRCol3117 MemRCol3217 1000.000000
R33118 MemRCol3118 MemRCol3218 1000.000000
R33119 MemRCol3119 MemRCol3219 1000.000000
R33120 MemRCol3120 MemRCol3220 1000.000000
R33121 MemRCol3121 MemRCol3221 1000.000000
R33122 MemRCol3122 MemRCol3222 1000.000000
R33123 MemRCol3123 MemRCol3223 1000.000000
R33124 MemRCol3124 MemRCol3224 1000.000000
R33125 MemRCol3125 MemRCol3225 1000.000000
R33126 MemRCol3126 MemRCol3226 1000.000000
R33127 MemRCol3127 MemRCol3227 1000.000000
R33128 MemRCol3128 MemRCol3228 1000.000000
R33129 MemRCol3129 MemRCol3229 1000.000000
R33130 MemRCol3130 MemRCol3230 1000.000000
R33131 MemRCol3131 MemRCol3231 1000.000000
R33132 MemRCol3132 MemRCol3232 1000.000000
R33133 MemRCol3133 MemRCol3233 1000.000000
R33134 MemRCol3134 MemRCol3234 1000.000000
R33135 MemRCol3135 MemRCol3235 1000.000000
R33136 MemRCol3136 MemRCol3236 1000.000000
R33137 MemRCol3137 MemRCol3237 1000.000000
R33138 MemRCol3138 MemRCol3238 1000.000000
R33139 MemRCol3139 MemRCol3239 1000.000000
R33140 MemRCol3140 MemRCol3240 1000.000000
R33141 MemRCol3141 MemRCol3241 1000.000000
R33142 MemRCol3142 MemRCol3242 1000.000000
R33143 MemRCol3143 MemRCol3243 1000.000000
R33144 MemRCol3144 MemRCol3244 1000.000000
R33145 MemRCol3145 MemRCol3245 1000.000000
R33146 MemRCol3146 MemRCol3246 1000.000000
R33147 MemRCol3147 MemRCol3247 1000.000000
R33148 MemRCol3148 MemRCol3248 1000.000000
R33149 MemRCol3149 MemRCol3249 1000.000000
R33150 MemRCol3150 MemRCol3250 1000.000000
R3321 MemRCol321 MemRCol331 1000.000000
R3322 MemRCol322 MemRCol332 1000.000000
R3323 MemRCol323 MemRCol333 1000.000000
R3324 MemRCol324 MemRCol334 1000.000000
R3325 MemRCol325 MemRCol335 1000.000000
R3326 MemRCol326 MemRCol336 1000.000000
R3327 MemRCol327 MemRCol337 1000.000000
R3328 MemRCol328 MemRCol338 1000.000000
R3329 MemRCol329 MemRCol339 1000.000000
R33210 MemRCol3210 MemRCol3310 1000.000000
R33211 MemRCol3211 MemRCol3311 1000.000000
R33212 MemRCol3212 MemRCol3312 1000.000000
R33213 MemRCol3213 MemRCol3313 1000.000000
R33214 MemRCol3214 MemRCol3314 1000.000000
R33215 MemRCol3215 MemRCol3315 1000.000000
R33216 MemRCol3216 MemRCol3316 1000.000000
R33217 MemRCol3217 MemRCol3317 1000.000000
R33218 MemRCol3218 MemRCol3318 1000.000000
R33219 MemRCol3219 MemRCol3319 1000.000000
R33220 MemRCol3220 MemRCol3320 1000.000000
R33221 MemRCol3221 MemRCol3321 1000.000000
R33222 MemRCol3222 MemRCol3322 1000.000000
R33223 MemRCol3223 MemRCol3323 1000.000000
R33224 MemRCol3224 MemRCol3324 1000.000000
R33225 MemRCol3225 MemRCol3325 1000.000000
R33226 MemRCol3226 MemRCol3326 1000.000000
R33227 MemRCol3227 MemRCol3327 1000.000000
R33228 MemRCol3228 MemRCol3328 1000.000000
R33229 MemRCol3229 MemRCol3329 1000.000000
R33230 MemRCol3230 MemRCol3330 1000.000000
R33231 MemRCol3231 MemRCol3331 1000.000000
R33232 MemRCol3232 MemRCol3332 1000.000000
R33233 MemRCol3233 MemRCol3333 1000.000000
R33234 MemRCol3234 MemRCol3334 1000.000000
R33235 MemRCol3235 MemRCol3335 1000.000000
R33236 MemRCol3236 MemRCol3336 1000.000000
R33237 MemRCol3237 MemRCol3337 1000.000000
R33238 MemRCol3238 MemRCol3338 1000.000000
R33239 MemRCol3239 MemRCol3339 1000.000000
R33240 MemRCol3240 MemRCol3340 1000.000000
R33241 MemRCol3241 MemRCol3341 1000.000000
R33242 MemRCol3242 MemRCol3342 1000.000000
R33243 MemRCol3243 MemRCol3343 1000.000000
R33244 MemRCol3244 MemRCol3344 1000.000000
R33245 MemRCol3245 MemRCol3345 1000.000000
R33246 MemRCol3246 MemRCol3346 1000.000000
R33247 MemRCol3247 MemRCol3347 1000.000000
R33248 MemRCol3248 MemRCol3348 1000.000000
R33249 MemRCol3249 MemRCol3349 1000.000000
R33250 MemRCol3250 MemRCol3350 1000.000000
R3331 MemRCol331 MemRCol341 1000.000000
R3332 MemRCol332 MemRCol342 1000.000000
R3333 MemRCol333 MemRCol343 1000.000000
R3334 MemRCol334 MemRCol344 1000.000000
R3335 MemRCol335 MemRCol345 1000.000000
R3336 MemRCol336 MemRCol346 1000.000000
R3337 MemRCol337 MemRCol347 1000.000000
R3338 MemRCol338 MemRCol348 1000.000000
R3339 MemRCol339 MemRCol349 1000.000000
R33310 MemRCol3310 MemRCol3410 1000.000000
R33311 MemRCol3311 MemRCol3411 1000.000000
R33312 MemRCol3312 MemRCol3412 1000.000000
R33313 MemRCol3313 MemRCol3413 1000.000000
R33314 MemRCol3314 MemRCol3414 1000.000000
R33315 MemRCol3315 MemRCol3415 1000.000000
R33316 MemRCol3316 MemRCol3416 1000.000000
R33317 MemRCol3317 MemRCol3417 1000.000000
R33318 MemRCol3318 MemRCol3418 1000.000000
R33319 MemRCol3319 MemRCol3419 1000.000000
R33320 MemRCol3320 MemRCol3420 1000.000000
R33321 MemRCol3321 MemRCol3421 1000.000000
R33322 MemRCol3322 MemRCol3422 1000.000000
R33323 MemRCol3323 MemRCol3423 1000.000000
R33324 MemRCol3324 MemRCol3424 1000.000000
R33325 MemRCol3325 MemRCol3425 1000.000000
R33326 MemRCol3326 MemRCol3426 1000.000000
R33327 MemRCol3327 MemRCol3427 1000.000000
R33328 MemRCol3328 MemRCol3428 1000.000000
R33329 MemRCol3329 MemRCol3429 1000.000000
R33330 MemRCol3330 MemRCol3430 1000.000000
R33331 MemRCol3331 MemRCol3431 1000.000000
R33332 MemRCol3332 MemRCol3432 1000.000000
R33333 MemRCol3333 MemRCol3433 1000.000000
R33334 MemRCol3334 MemRCol3434 1000.000000
R33335 MemRCol3335 MemRCol3435 1000.000000
R33336 MemRCol3336 MemRCol3436 1000.000000
R33337 MemRCol3337 MemRCol3437 1000.000000
R33338 MemRCol3338 MemRCol3438 1000.000000
R33339 MemRCol3339 MemRCol3439 1000.000000
R33340 MemRCol3340 MemRCol3440 1000.000000
R33341 MemRCol3341 MemRCol3441 1000.000000
R33342 MemRCol3342 MemRCol3442 1000.000000
R33343 MemRCol3343 MemRCol3443 1000.000000
R33344 MemRCol3344 MemRCol3444 1000.000000
R33345 MemRCol3345 MemRCol3445 1000.000000
R33346 MemRCol3346 MemRCol3446 1000.000000
R33347 MemRCol3347 MemRCol3447 1000.000000
R33348 MemRCol3348 MemRCol3448 1000.000000
R33349 MemRCol3349 MemRCol3449 1000.000000
R33350 MemRCol3350 MemRCol3450 1000.000000
R3341 MemRCol341 MemRCol351 1000.000000
R3342 MemRCol342 MemRCol352 1000.000000
R3343 MemRCol343 MemRCol353 1000.000000
R3344 MemRCol344 MemRCol354 1000.000000
R3345 MemRCol345 MemRCol355 1000.000000
R3346 MemRCol346 MemRCol356 1000.000000
R3347 MemRCol347 MemRCol357 1000.000000
R3348 MemRCol348 MemRCol358 1000.000000
R3349 MemRCol349 MemRCol359 1000.000000
R33410 MemRCol3410 MemRCol3510 1000.000000
R33411 MemRCol3411 MemRCol3511 1000.000000
R33412 MemRCol3412 MemRCol3512 1000.000000
R33413 MemRCol3413 MemRCol3513 1000.000000
R33414 MemRCol3414 MemRCol3514 1000.000000
R33415 MemRCol3415 MemRCol3515 1000.000000
R33416 MemRCol3416 MemRCol3516 1000.000000
R33417 MemRCol3417 MemRCol3517 1000.000000
R33418 MemRCol3418 MemRCol3518 1000.000000
R33419 MemRCol3419 MemRCol3519 1000.000000
R33420 MemRCol3420 MemRCol3520 1000.000000
R33421 MemRCol3421 MemRCol3521 1000.000000
R33422 MemRCol3422 MemRCol3522 1000.000000
R33423 MemRCol3423 MemRCol3523 1000.000000
R33424 MemRCol3424 MemRCol3524 1000.000000
R33425 MemRCol3425 MemRCol3525 1000.000000
R33426 MemRCol3426 MemRCol3526 1000.000000
R33427 MemRCol3427 MemRCol3527 1000.000000
R33428 MemRCol3428 MemRCol3528 1000.000000
R33429 MemRCol3429 MemRCol3529 1000.000000
R33430 MemRCol3430 MemRCol3530 1000.000000
R33431 MemRCol3431 MemRCol3531 1000.000000
R33432 MemRCol3432 MemRCol3532 1000.000000
R33433 MemRCol3433 MemRCol3533 1000.000000
R33434 MemRCol3434 MemRCol3534 1000.000000
R33435 MemRCol3435 MemRCol3535 1000.000000
R33436 MemRCol3436 MemRCol3536 1000.000000
R33437 MemRCol3437 MemRCol3537 1000.000000
R33438 MemRCol3438 MemRCol3538 1000.000000
R33439 MemRCol3439 MemRCol3539 1000.000000
R33440 MemRCol3440 MemRCol3540 1000.000000
R33441 MemRCol3441 MemRCol3541 1000.000000
R33442 MemRCol3442 MemRCol3542 1000.000000
R33443 MemRCol3443 MemRCol3543 1000.000000
R33444 MemRCol3444 MemRCol3544 1000.000000
R33445 MemRCol3445 MemRCol3545 1000.000000
R33446 MemRCol3446 MemRCol3546 1000.000000
R33447 MemRCol3447 MemRCol3547 1000.000000
R33448 MemRCol3448 MemRCol3548 1000.000000
R33449 MemRCol3449 MemRCol3549 1000.000000
R33450 MemRCol3450 MemRCol3550 1000.000000
R3351 MemRCol351 MemRCol361 1000.000000
R3352 MemRCol352 MemRCol362 1000.000000
R3353 MemRCol353 MemRCol363 1000.000000
R3354 MemRCol354 MemRCol364 1000.000000
R3355 MemRCol355 MemRCol365 1000.000000
R3356 MemRCol356 MemRCol366 1000.000000
R3357 MemRCol357 MemRCol367 1000.000000
R3358 MemRCol358 MemRCol368 1000.000000
R3359 MemRCol359 MemRCol369 1000.000000
R33510 MemRCol3510 MemRCol3610 1000.000000
R33511 MemRCol3511 MemRCol3611 1000.000000
R33512 MemRCol3512 MemRCol3612 1000.000000
R33513 MemRCol3513 MemRCol3613 1000.000000
R33514 MemRCol3514 MemRCol3614 1000.000000
R33515 MemRCol3515 MemRCol3615 1000.000000
R33516 MemRCol3516 MemRCol3616 1000.000000
R33517 MemRCol3517 MemRCol3617 1000.000000
R33518 MemRCol3518 MemRCol3618 1000.000000
R33519 MemRCol3519 MemRCol3619 1000.000000
R33520 MemRCol3520 MemRCol3620 1000.000000
R33521 MemRCol3521 MemRCol3621 1000.000000
R33522 MemRCol3522 MemRCol3622 1000.000000
R33523 MemRCol3523 MemRCol3623 1000.000000
R33524 MemRCol3524 MemRCol3624 1000.000000
R33525 MemRCol3525 MemRCol3625 1000.000000
R33526 MemRCol3526 MemRCol3626 1000.000000
R33527 MemRCol3527 MemRCol3627 1000.000000
R33528 MemRCol3528 MemRCol3628 1000.000000
R33529 MemRCol3529 MemRCol3629 1000.000000
R33530 MemRCol3530 MemRCol3630 1000.000000
R33531 MemRCol3531 MemRCol3631 1000.000000
R33532 MemRCol3532 MemRCol3632 1000.000000
R33533 MemRCol3533 MemRCol3633 1000.000000
R33534 MemRCol3534 MemRCol3634 1000.000000
R33535 MemRCol3535 MemRCol3635 1000.000000
R33536 MemRCol3536 MemRCol3636 1000.000000
R33537 MemRCol3537 MemRCol3637 1000.000000
R33538 MemRCol3538 MemRCol3638 1000.000000
R33539 MemRCol3539 MemRCol3639 1000.000000
R33540 MemRCol3540 MemRCol3640 1000.000000
R33541 MemRCol3541 MemRCol3641 1000.000000
R33542 MemRCol3542 MemRCol3642 1000.000000
R33543 MemRCol3543 MemRCol3643 1000.000000
R33544 MemRCol3544 MemRCol3644 1000.000000
R33545 MemRCol3545 MemRCol3645 1000.000000
R33546 MemRCol3546 MemRCol3646 1000.000000
R33547 MemRCol3547 MemRCol3647 1000.000000
R33548 MemRCol3548 MemRCol3648 1000.000000
R33549 MemRCol3549 MemRCol3649 1000.000000
R33550 MemRCol3550 MemRCol3650 1000.000000
R3361 MemRCol361 MemRCol371 1000.000000
R3362 MemRCol362 MemRCol372 1000.000000
R3363 MemRCol363 MemRCol373 1000.000000
R3364 MemRCol364 MemRCol374 1000.000000
R3365 MemRCol365 MemRCol375 1000.000000
R3366 MemRCol366 MemRCol376 1000.000000
R3367 MemRCol367 MemRCol377 1000.000000
R3368 MemRCol368 MemRCol378 1000.000000
R3369 MemRCol369 MemRCol379 1000.000000
R33610 MemRCol3610 MemRCol3710 1000.000000
R33611 MemRCol3611 MemRCol3711 1000.000000
R33612 MemRCol3612 MemRCol3712 1000.000000
R33613 MemRCol3613 MemRCol3713 1000.000000
R33614 MemRCol3614 MemRCol3714 1000.000000
R33615 MemRCol3615 MemRCol3715 1000.000000
R33616 MemRCol3616 MemRCol3716 1000.000000
R33617 MemRCol3617 MemRCol3717 1000.000000
R33618 MemRCol3618 MemRCol3718 1000.000000
R33619 MemRCol3619 MemRCol3719 1000.000000
R33620 MemRCol3620 MemRCol3720 1000.000000
R33621 MemRCol3621 MemRCol3721 1000.000000
R33622 MemRCol3622 MemRCol3722 1000.000000
R33623 MemRCol3623 MemRCol3723 1000.000000
R33624 MemRCol3624 MemRCol3724 1000.000000
R33625 MemRCol3625 MemRCol3725 1000.000000
R33626 MemRCol3626 MemRCol3726 1000.000000
R33627 MemRCol3627 MemRCol3727 1000.000000
R33628 MemRCol3628 MemRCol3728 1000.000000
R33629 MemRCol3629 MemRCol3729 1000.000000
R33630 MemRCol3630 MemRCol3730 1000.000000
R33631 MemRCol3631 MemRCol3731 1000.000000
R33632 MemRCol3632 MemRCol3732 1000.000000
R33633 MemRCol3633 MemRCol3733 1000.000000
R33634 MemRCol3634 MemRCol3734 1000.000000
R33635 MemRCol3635 MemRCol3735 1000.000000
R33636 MemRCol3636 MemRCol3736 1000.000000
R33637 MemRCol3637 MemRCol3737 1000.000000
R33638 MemRCol3638 MemRCol3738 1000.000000
R33639 MemRCol3639 MemRCol3739 1000.000000
R33640 MemRCol3640 MemRCol3740 1000.000000
R33641 MemRCol3641 MemRCol3741 1000.000000
R33642 MemRCol3642 MemRCol3742 1000.000000
R33643 MemRCol3643 MemRCol3743 1000.000000
R33644 MemRCol3644 MemRCol3744 1000.000000
R33645 MemRCol3645 MemRCol3745 1000.000000
R33646 MemRCol3646 MemRCol3746 1000.000000
R33647 MemRCol3647 MemRCol3747 1000.000000
R33648 MemRCol3648 MemRCol3748 1000.000000
R33649 MemRCol3649 MemRCol3749 1000.000000
R33650 MemRCol3650 MemRCol3750 1000.000000
R3371 MemRCol371 MemRCol381 1000.000000
R3372 MemRCol372 MemRCol382 1000.000000
R3373 MemRCol373 MemRCol383 1000.000000
R3374 MemRCol374 MemRCol384 1000.000000
R3375 MemRCol375 MemRCol385 1000.000000
R3376 MemRCol376 MemRCol386 1000.000000
R3377 MemRCol377 MemRCol387 1000.000000
R3378 MemRCol378 MemRCol388 1000.000000
R3379 MemRCol379 MemRCol389 1000.000000
R33710 MemRCol3710 MemRCol3810 1000.000000
R33711 MemRCol3711 MemRCol3811 1000.000000
R33712 MemRCol3712 MemRCol3812 1000.000000
R33713 MemRCol3713 MemRCol3813 1000.000000
R33714 MemRCol3714 MemRCol3814 1000.000000
R33715 MemRCol3715 MemRCol3815 1000.000000
R33716 MemRCol3716 MemRCol3816 1000.000000
R33717 MemRCol3717 MemRCol3817 1000.000000
R33718 MemRCol3718 MemRCol3818 1000.000000
R33719 MemRCol3719 MemRCol3819 1000.000000
R33720 MemRCol3720 MemRCol3820 1000.000000
R33721 MemRCol3721 MemRCol3821 1000.000000
R33722 MemRCol3722 MemRCol3822 1000.000000
R33723 MemRCol3723 MemRCol3823 1000.000000
R33724 MemRCol3724 MemRCol3824 1000.000000
R33725 MemRCol3725 MemRCol3825 1000.000000
R33726 MemRCol3726 MemRCol3826 1000.000000
R33727 MemRCol3727 MemRCol3827 1000.000000
R33728 MemRCol3728 MemRCol3828 1000.000000
R33729 MemRCol3729 MemRCol3829 1000.000000
R33730 MemRCol3730 MemRCol3830 1000.000000
R33731 MemRCol3731 MemRCol3831 1000.000000
R33732 MemRCol3732 MemRCol3832 1000.000000
R33733 MemRCol3733 MemRCol3833 1000.000000
R33734 MemRCol3734 MemRCol3834 1000.000000
R33735 MemRCol3735 MemRCol3835 1000.000000
R33736 MemRCol3736 MemRCol3836 1000.000000
R33737 MemRCol3737 MemRCol3837 1000.000000
R33738 MemRCol3738 MemRCol3838 1000.000000
R33739 MemRCol3739 MemRCol3839 1000.000000
R33740 MemRCol3740 MemRCol3840 1000.000000
R33741 MemRCol3741 MemRCol3841 1000.000000
R33742 MemRCol3742 MemRCol3842 1000.000000
R33743 MemRCol3743 MemRCol3843 1000.000000
R33744 MemRCol3744 MemRCol3844 1000.000000
R33745 MemRCol3745 MemRCol3845 1000.000000
R33746 MemRCol3746 MemRCol3846 1000.000000
R33747 MemRCol3747 MemRCol3847 1000.000000
R33748 MemRCol3748 MemRCol3848 1000.000000
R33749 MemRCol3749 MemRCol3849 1000.000000
R33750 MemRCol3750 MemRCol3850 1000.000000
R3381 MemRCol381 MemRCol391 1000.000000
R3382 MemRCol382 MemRCol392 1000.000000
R3383 MemRCol383 MemRCol393 1000.000000
R3384 MemRCol384 MemRCol394 1000.000000
R3385 MemRCol385 MemRCol395 1000.000000
R3386 MemRCol386 MemRCol396 1000.000000
R3387 MemRCol387 MemRCol397 1000.000000
R3388 MemRCol388 MemRCol398 1000.000000
R3389 MemRCol389 MemRCol399 1000.000000
R33810 MemRCol3810 MemRCol3910 1000.000000
R33811 MemRCol3811 MemRCol3911 1000.000000
R33812 MemRCol3812 MemRCol3912 1000.000000
R33813 MemRCol3813 MemRCol3913 1000.000000
R33814 MemRCol3814 MemRCol3914 1000.000000
R33815 MemRCol3815 MemRCol3915 1000.000000
R33816 MemRCol3816 MemRCol3916 1000.000000
R33817 MemRCol3817 MemRCol3917 1000.000000
R33818 MemRCol3818 MemRCol3918 1000.000000
R33819 MemRCol3819 MemRCol3919 1000.000000
R33820 MemRCol3820 MemRCol3920 1000.000000
R33821 MemRCol3821 MemRCol3921 1000.000000
R33822 MemRCol3822 MemRCol3922 1000.000000
R33823 MemRCol3823 MemRCol3923 1000.000000
R33824 MemRCol3824 MemRCol3924 1000.000000
R33825 MemRCol3825 MemRCol3925 1000.000000
R33826 MemRCol3826 MemRCol3926 1000.000000
R33827 MemRCol3827 MemRCol3927 1000.000000
R33828 MemRCol3828 MemRCol3928 1000.000000
R33829 MemRCol3829 MemRCol3929 1000.000000
R33830 MemRCol3830 MemRCol3930 1000.000000
R33831 MemRCol3831 MemRCol3931 1000.000000
R33832 MemRCol3832 MemRCol3932 1000.000000
R33833 MemRCol3833 MemRCol3933 1000.000000
R33834 MemRCol3834 MemRCol3934 1000.000000
R33835 MemRCol3835 MemRCol3935 1000.000000
R33836 MemRCol3836 MemRCol3936 1000.000000
R33837 MemRCol3837 MemRCol3937 1000.000000
R33838 MemRCol3838 MemRCol3938 1000.000000
R33839 MemRCol3839 MemRCol3939 1000.000000
R33840 MemRCol3840 MemRCol3940 1000.000000
R33841 MemRCol3841 MemRCol3941 1000.000000
R33842 MemRCol3842 MemRCol3942 1000.000000
R33843 MemRCol3843 MemRCol3943 1000.000000
R33844 MemRCol3844 MemRCol3944 1000.000000
R33845 MemRCol3845 MemRCol3945 1000.000000
R33846 MemRCol3846 MemRCol3946 1000.000000
R33847 MemRCol3847 MemRCol3947 1000.000000
R33848 MemRCol3848 MemRCol3948 1000.000000
R33849 MemRCol3849 MemRCol3949 1000.000000
R33850 MemRCol3850 MemRCol3950 1000.000000
R3391 MemRCol391 MemRCol401 1000.000000
R3392 MemRCol392 MemRCol402 1000.000000
R3393 MemRCol393 MemRCol403 1000.000000
R3394 MemRCol394 MemRCol404 1000.000000
R3395 MemRCol395 MemRCol405 1000.000000
R3396 MemRCol396 MemRCol406 1000.000000
R3397 MemRCol397 MemRCol407 1000.000000
R3398 MemRCol398 MemRCol408 1000.000000
R3399 MemRCol399 MemRCol409 1000.000000
R33910 MemRCol3910 MemRCol4010 1000.000000
R33911 MemRCol3911 MemRCol4011 1000.000000
R33912 MemRCol3912 MemRCol4012 1000.000000
R33913 MemRCol3913 MemRCol4013 1000.000000
R33914 MemRCol3914 MemRCol4014 1000.000000
R33915 MemRCol3915 MemRCol4015 1000.000000
R33916 MemRCol3916 MemRCol4016 1000.000000
R33917 MemRCol3917 MemRCol4017 1000.000000
R33918 MemRCol3918 MemRCol4018 1000.000000
R33919 MemRCol3919 MemRCol4019 1000.000000
R33920 MemRCol3920 MemRCol4020 1000.000000
R33921 MemRCol3921 MemRCol4021 1000.000000
R33922 MemRCol3922 MemRCol4022 1000.000000
R33923 MemRCol3923 MemRCol4023 1000.000000
R33924 MemRCol3924 MemRCol4024 1000.000000
R33925 MemRCol3925 MemRCol4025 1000.000000
R33926 MemRCol3926 MemRCol4026 1000.000000
R33927 MemRCol3927 MemRCol4027 1000.000000
R33928 MemRCol3928 MemRCol4028 1000.000000
R33929 MemRCol3929 MemRCol4029 1000.000000
R33930 MemRCol3930 MemRCol4030 1000.000000
R33931 MemRCol3931 MemRCol4031 1000.000000
R33932 MemRCol3932 MemRCol4032 1000.000000
R33933 MemRCol3933 MemRCol4033 1000.000000
R33934 MemRCol3934 MemRCol4034 1000.000000
R33935 MemRCol3935 MemRCol4035 1000.000000
R33936 MemRCol3936 MemRCol4036 1000.000000
R33937 MemRCol3937 MemRCol4037 1000.000000
R33938 MemRCol3938 MemRCol4038 1000.000000
R33939 MemRCol3939 MemRCol4039 1000.000000
R33940 MemRCol3940 MemRCol4040 1000.000000
R33941 MemRCol3941 MemRCol4041 1000.000000
R33942 MemRCol3942 MemRCol4042 1000.000000
R33943 MemRCol3943 MemRCol4043 1000.000000
R33944 MemRCol3944 MemRCol4044 1000.000000
R33945 MemRCol3945 MemRCol4045 1000.000000
R33946 MemRCol3946 MemRCol4046 1000.000000
R33947 MemRCol3947 MemRCol4047 1000.000000
R33948 MemRCol3948 MemRCol4048 1000.000000
R33949 MemRCol3949 MemRCol4049 1000.000000
R33950 MemRCol3950 MemRCol4050 1000.000000
R3401 MemRCol401 MemRCol411 1000.000000
R3402 MemRCol402 MemRCol412 1000.000000
R3403 MemRCol403 MemRCol413 1000.000000
R3404 MemRCol404 MemRCol414 1000.000000
R3405 MemRCol405 MemRCol415 1000.000000
R3406 MemRCol406 MemRCol416 1000.000000
R3407 MemRCol407 MemRCol417 1000.000000
R3408 MemRCol408 MemRCol418 1000.000000
R3409 MemRCol409 MemRCol419 1000.000000
R34010 MemRCol4010 MemRCol4110 1000.000000
R34011 MemRCol4011 MemRCol4111 1000.000000
R34012 MemRCol4012 MemRCol4112 1000.000000
R34013 MemRCol4013 MemRCol4113 1000.000000
R34014 MemRCol4014 MemRCol4114 1000.000000
R34015 MemRCol4015 MemRCol4115 1000.000000
R34016 MemRCol4016 MemRCol4116 1000.000000
R34017 MemRCol4017 MemRCol4117 1000.000000
R34018 MemRCol4018 MemRCol4118 1000.000000
R34019 MemRCol4019 MemRCol4119 1000.000000
R34020 MemRCol4020 MemRCol4120 1000.000000
R34021 MemRCol4021 MemRCol4121 1000.000000
R34022 MemRCol4022 MemRCol4122 1000.000000
R34023 MemRCol4023 MemRCol4123 1000.000000
R34024 MemRCol4024 MemRCol4124 1000.000000
R34025 MemRCol4025 MemRCol4125 1000.000000
R34026 MemRCol4026 MemRCol4126 1000.000000
R34027 MemRCol4027 MemRCol4127 1000.000000
R34028 MemRCol4028 MemRCol4128 1000.000000
R34029 MemRCol4029 MemRCol4129 1000.000000
R34030 MemRCol4030 MemRCol4130 1000.000000
R34031 MemRCol4031 MemRCol4131 1000.000000
R34032 MemRCol4032 MemRCol4132 1000.000000
R34033 MemRCol4033 MemRCol4133 1000.000000
R34034 MemRCol4034 MemRCol4134 1000.000000
R34035 MemRCol4035 MemRCol4135 1000.000000
R34036 MemRCol4036 MemRCol4136 1000.000000
R34037 MemRCol4037 MemRCol4137 1000.000000
R34038 MemRCol4038 MemRCol4138 1000.000000
R34039 MemRCol4039 MemRCol4139 1000.000000
R34040 MemRCol4040 MemRCol4140 1000.000000
R34041 MemRCol4041 MemRCol4141 1000.000000
R34042 MemRCol4042 MemRCol4142 1000.000000
R34043 MemRCol4043 MemRCol4143 1000.000000
R34044 MemRCol4044 MemRCol4144 1000.000000
R34045 MemRCol4045 MemRCol4145 1000.000000
R34046 MemRCol4046 MemRCol4146 1000.000000
R34047 MemRCol4047 MemRCol4147 1000.000000
R34048 MemRCol4048 MemRCol4148 1000.000000
R34049 MemRCol4049 MemRCol4149 1000.000000
R34050 MemRCol4050 MemRCol4150 1000.000000
R3411 MemRCol411 MemRCol421 1000.000000
R3412 MemRCol412 MemRCol422 1000.000000
R3413 MemRCol413 MemRCol423 1000.000000
R3414 MemRCol414 MemRCol424 1000.000000
R3415 MemRCol415 MemRCol425 1000.000000
R3416 MemRCol416 MemRCol426 1000.000000
R3417 MemRCol417 MemRCol427 1000.000000
R3418 MemRCol418 MemRCol428 1000.000000
R3419 MemRCol419 MemRCol429 1000.000000
R34110 MemRCol4110 MemRCol4210 1000.000000
R34111 MemRCol4111 MemRCol4211 1000.000000
R34112 MemRCol4112 MemRCol4212 1000.000000
R34113 MemRCol4113 MemRCol4213 1000.000000
R34114 MemRCol4114 MemRCol4214 1000.000000
R34115 MemRCol4115 MemRCol4215 1000.000000
R34116 MemRCol4116 MemRCol4216 1000.000000
R34117 MemRCol4117 MemRCol4217 1000.000000
R34118 MemRCol4118 MemRCol4218 1000.000000
R34119 MemRCol4119 MemRCol4219 1000.000000
R34120 MemRCol4120 MemRCol4220 1000.000000
R34121 MemRCol4121 MemRCol4221 1000.000000
R34122 MemRCol4122 MemRCol4222 1000.000000
R34123 MemRCol4123 MemRCol4223 1000.000000
R34124 MemRCol4124 MemRCol4224 1000.000000
R34125 MemRCol4125 MemRCol4225 1000.000000
R34126 MemRCol4126 MemRCol4226 1000.000000
R34127 MemRCol4127 MemRCol4227 1000.000000
R34128 MemRCol4128 MemRCol4228 1000.000000
R34129 MemRCol4129 MemRCol4229 1000.000000
R34130 MemRCol4130 MemRCol4230 1000.000000
R34131 MemRCol4131 MemRCol4231 1000.000000
R34132 MemRCol4132 MemRCol4232 1000.000000
R34133 MemRCol4133 MemRCol4233 1000.000000
R34134 MemRCol4134 MemRCol4234 1000.000000
R34135 MemRCol4135 MemRCol4235 1000.000000
R34136 MemRCol4136 MemRCol4236 1000.000000
R34137 MemRCol4137 MemRCol4237 1000.000000
R34138 MemRCol4138 MemRCol4238 1000.000000
R34139 MemRCol4139 MemRCol4239 1000.000000
R34140 MemRCol4140 MemRCol4240 1000.000000
R34141 MemRCol4141 MemRCol4241 1000.000000
R34142 MemRCol4142 MemRCol4242 1000.000000
R34143 MemRCol4143 MemRCol4243 1000.000000
R34144 MemRCol4144 MemRCol4244 1000.000000
R34145 MemRCol4145 MemRCol4245 1000.000000
R34146 MemRCol4146 MemRCol4246 1000.000000
R34147 MemRCol4147 MemRCol4247 1000.000000
R34148 MemRCol4148 MemRCol4248 1000.000000
R34149 MemRCol4149 MemRCol4249 1000.000000
R34150 MemRCol4150 MemRCol4250 1000.000000
R3421 MemRCol421 MemRCol431 1000.000000
R3422 MemRCol422 MemRCol432 1000.000000
R3423 MemRCol423 MemRCol433 1000.000000
R3424 MemRCol424 MemRCol434 1000.000000
R3425 MemRCol425 MemRCol435 1000.000000
R3426 MemRCol426 MemRCol436 1000.000000
R3427 MemRCol427 MemRCol437 1000.000000
R3428 MemRCol428 MemRCol438 1000.000000
R3429 MemRCol429 MemRCol439 1000.000000
R34210 MemRCol4210 MemRCol4310 1000.000000
R34211 MemRCol4211 MemRCol4311 1000.000000
R34212 MemRCol4212 MemRCol4312 1000.000000
R34213 MemRCol4213 MemRCol4313 1000.000000
R34214 MemRCol4214 MemRCol4314 1000.000000
R34215 MemRCol4215 MemRCol4315 1000.000000
R34216 MemRCol4216 MemRCol4316 1000.000000
R34217 MemRCol4217 MemRCol4317 1000.000000
R34218 MemRCol4218 MemRCol4318 1000.000000
R34219 MemRCol4219 MemRCol4319 1000.000000
R34220 MemRCol4220 MemRCol4320 1000.000000
R34221 MemRCol4221 MemRCol4321 1000.000000
R34222 MemRCol4222 MemRCol4322 1000.000000
R34223 MemRCol4223 MemRCol4323 1000.000000
R34224 MemRCol4224 MemRCol4324 1000.000000
R34225 MemRCol4225 MemRCol4325 1000.000000
R34226 MemRCol4226 MemRCol4326 1000.000000
R34227 MemRCol4227 MemRCol4327 1000.000000
R34228 MemRCol4228 MemRCol4328 1000.000000
R34229 MemRCol4229 MemRCol4329 1000.000000
R34230 MemRCol4230 MemRCol4330 1000.000000
R34231 MemRCol4231 MemRCol4331 1000.000000
R34232 MemRCol4232 MemRCol4332 1000.000000
R34233 MemRCol4233 MemRCol4333 1000.000000
R34234 MemRCol4234 MemRCol4334 1000.000000
R34235 MemRCol4235 MemRCol4335 1000.000000
R34236 MemRCol4236 MemRCol4336 1000.000000
R34237 MemRCol4237 MemRCol4337 1000.000000
R34238 MemRCol4238 MemRCol4338 1000.000000
R34239 MemRCol4239 MemRCol4339 1000.000000
R34240 MemRCol4240 MemRCol4340 1000.000000
R34241 MemRCol4241 MemRCol4341 1000.000000
R34242 MemRCol4242 MemRCol4342 1000.000000
R34243 MemRCol4243 MemRCol4343 1000.000000
R34244 MemRCol4244 MemRCol4344 1000.000000
R34245 MemRCol4245 MemRCol4345 1000.000000
R34246 MemRCol4246 MemRCol4346 1000.000000
R34247 MemRCol4247 MemRCol4347 1000.000000
R34248 MemRCol4248 MemRCol4348 1000.000000
R34249 MemRCol4249 MemRCol4349 1000.000000
R34250 MemRCol4250 MemRCol4350 1000.000000
R3431 MemRCol431 MemRCol441 1000.000000
R3432 MemRCol432 MemRCol442 1000.000000
R3433 MemRCol433 MemRCol443 1000.000000
R3434 MemRCol434 MemRCol444 1000.000000
R3435 MemRCol435 MemRCol445 1000.000000
R3436 MemRCol436 MemRCol446 1000.000000
R3437 MemRCol437 MemRCol447 1000.000000
R3438 MemRCol438 MemRCol448 1000.000000
R3439 MemRCol439 MemRCol449 1000.000000
R34310 MemRCol4310 MemRCol4410 1000.000000
R34311 MemRCol4311 MemRCol4411 1000.000000
R34312 MemRCol4312 MemRCol4412 1000.000000
R34313 MemRCol4313 MemRCol4413 1000.000000
R34314 MemRCol4314 MemRCol4414 1000.000000
R34315 MemRCol4315 MemRCol4415 1000.000000
R34316 MemRCol4316 MemRCol4416 1000.000000
R34317 MemRCol4317 MemRCol4417 1000.000000
R34318 MemRCol4318 MemRCol4418 1000.000000
R34319 MemRCol4319 MemRCol4419 1000.000000
R34320 MemRCol4320 MemRCol4420 1000.000000
R34321 MemRCol4321 MemRCol4421 1000.000000
R34322 MemRCol4322 MemRCol4422 1000.000000
R34323 MemRCol4323 MemRCol4423 1000.000000
R34324 MemRCol4324 MemRCol4424 1000.000000
R34325 MemRCol4325 MemRCol4425 1000.000000
R34326 MemRCol4326 MemRCol4426 1000.000000
R34327 MemRCol4327 MemRCol4427 1000.000000
R34328 MemRCol4328 MemRCol4428 1000.000000
R34329 MemRCol4329 MemRCol4429 1000.000000
R34330 MemRCol4330 MemRCol4430 1000.000000
R34331 MemRCol4331 MemRCol4431 1000.000000
R34332 MemRCol4332 MemRCol4432 1000.000000
R34333 MemRCol4333 MemRCol4433 1000.000000
R34334 MemRCol4334 MemRCol4434 1000.000000
R34335 MemRCol4335 MemRCol4435 1000.000000
R34336 MemRCol4336 MemRCol4436 1000.000000
R34337 MemRCol4337 MemRCol4437 1000.000000
R34338 MemRCol4338 MemRCol4438 1000.000000
R34339 MemRCol4339 MemRCol4439 1000.000000
R34340 MemRCol4340 MemRCol4440 1000.000000
R34341 MemRCol4341 MemRCol4441 1000.000000
R34342 MemRCol4342 MemRCol4442 1000.000000
R34343 MemRCol4343 MemRCol4443 1000.000000
R34344 MemRCol4344 MemRCol4444 1000.000000
R34345 MemRCol4345 MemRCol4445 1000.000000
R34346 MemRCol4346 MemRCol4446 1000.000000
R34347 MemRCol4347 MemRCol4447 1000.000000
R34348 MemRCol4348 MemRCol4448 1000.000000
R34349 MemRCol4349 MemRCol4449 1000.000000
R34350 MemRCol4350 MemRCol4450 1000.000000
R3441 MemRCol441 MemRCol451 1000.000000
R3442 MemRCol442 MemRCol452 1000.000000
R3443 MemRCol443 MemRCol453 1000.000000
R3444 MemRCol444 MemRCol454 1000.000000
R3445 MemRCol445 MemRCol455 1000.000000
R3446 MemRCol446 MemRCol456 1000.000000
R3447 MemRCol447 MemRCol457 1000.000000
R3448 MemRCol448 MemRCol458 1000.000000
R3449 MemRCol449 MemRCol459 1000.000000
R34410 MemRCol4410 MemRCol4510 1000.000000
R34411 MemRCol4411 MemRCol4511 1000.000000
R34412 MemRCol4412 MemRCol4512 1000.000000
R34413 MemRCol4413 MemRCol4513 1000.000000
R34414 MemRCol4414 MemRCol4514 1000.000000
R34415 MemRCol4415 MemRCol4515 1000.000000
R34416 MemRCol4416 MemRCol4516 1000.000000
R34417 MemRCol4417 MemRCol4517 1000.000000
R34418 MemRCol4418 MemRCol4518 1000.000000
R34419 MemRCol4419 MemRCol4519 1000.000000
R34420 MemRCol4420 MemRCol4520 1000.000000
R34421 MemRCol4421 MemRCol4521 1000.000000
R34422 MemRCol4422 MemRCol4522 1000.000000
R34423 MemRCol4423 MemRCol4523 1000.000000
R34424 MemRCol4424 MemRCol4524 1000.000000
R34425 MemRCol4425 MemRCol4525 1000.000000
R34426 MemRCol4426 MemRCol4526 1000.000000
R34427 MemRCol4427 MemRCol4527 1000.000000
R34428 MemRCol4428 MemRCol4528 1000.000000
R34429 MemRCol4429 MemRCol4529 1000.000000
R34430 MemRCol4430 MemRCol4530 1000.000000
R34431 MemRCol4431 MemRCol4531 1000.000000
R34432 MemRCol4432 MemRCol4532 1000.000000
R34433 MemRCol4433 MemRCol4533 1000.000000
R34434 MemRCol4434 MemRCol4534 1000.000000
R34435 MemRCol4435 MemRCol4535 1000.000000
R34436 MemRCol4436 MemRCol4536 1000.000000
R34437 MemRCol4437 MemRCol4537 1000.000000
R34438 MemRCol4438 MemRCol4538 1000.000000
R34439 MemRCol4439 MemRCol4539 1000.000000
R34440 MemRCol4440 MemRCol4540 1000.000000
R34441 MemRCol4441 MemRCol4541 1000.000000
R34442 MemRCol4442 MemRCol4542 1000.000000
R34443 MemRCol4443 MemRCol4543 1000.000000
R34444 MemRCol4444 MemRCol4544 1000.000000
R34445 MemRCol4445 MemRCol4545 1000.000000
R34446 MemRCol4446 MemRCol4546 1000.000000
R34447 MemRCol4447 MemRCol4547 1000.000000
R34448 MemRCol4448 MemRCol4548 1000.000000
R34449 MemRCol4449 MemRCol4549 1000.000000
R34450 MemRCol4450 MemRCol4550 1000.000000
R3451 MemRCol451 MemRCol461 1000.000000
R3452 MemRCol452 MemRCol462 1000.000000
R3453 MemRCol453 MemRCol463 1000.000000
R3454 MemRCol454 MemRCol464 1000.000000
R3455 MemRCol455 MemRCol465 1000.000000
R3456 MemRCol456 MemRCol466 1000.000000
R3457 MemRCol457 MemRCol467 1000.000000
R3458 MemRCol458 MemRCol468 1000.000000
R3459 MemRCol459 MemRCol469 1000.000000
R34510 MemRCol4510 MemRCol4610 1000.000000
R34511 MemRCol4511 MemRCol4611 1000.000000
R34512 MemRCol4512 MemRCol4612 1000.000000
R34513 MemRCol4513 MemRCol4613 1000.000000
R34514 MemRCol4514 MemRCol4614 1000.000000
R34515 MemRCol4515 MemRCol4615 1000.000000
R34516 MemRCol4516 MemRCol4616 1000.000000
R34517 MemRCol4517 MemRCol4617 1000.000000
R34518 MemRCol4518 MemRCol4618 1000.000000
R34519 MemRCol4519 MemRCol4619 1000.000000
R34520 MemRCol4520 MemRCol4620 1000.000000
R34521 MemRCol4521 MemRCol4621 1000.000000
R34522 MemRCol4522 MemRCol4622 1000.000000
R34523 MemRCol4523 MemRCol4623 1000.000000
R34524 MemRCol4524 MemRCol4624 1000.000000
R34525 MemRCol4525 MemRCol4625 1000.000000
R34526 MemRCol4526 MemRCol4626 1000.000000
R34527 MemRCol4527 MemRCol4627 1000.000000
R34528 MemRCol4528 MemRCol4628 1000.000000
R34529 MemRCol4529 MemRCol4629 1000.000000
R34530 MemRCol4530 MemRCol4630 1000.000000
R34531 MemRCol4531 MemRCol4631 1000.000000
R34532 MemRCol4532 MemRCol4632 1000.000000
R34533 MemRCol4533 MemRCol4633 1000.000000
R34534 MemRCol4534 MemRCol4634 1000.000000
R34535 MemRCol4535 MemRCol4635 1000.000000
R34536 MemRCol4536 MemRCol4636 1000.000000
R34537 MemRCol4537 MemRCol4637 1000.000000
R34538 MemRCol4538 MemRCol4638 1000.000000
R34539 MemRCol4539 MemRCol4639 1000.000000
R34540 MemRCol4540 MemRCol4640 1000.000000
R34541 MemRCol4541 MemRCol4641 1000.000000
R34542 MemRCol4542 MemRCol4642 1000.000000
R34543 MemRCol4543 MemRCol4643 1000.000000
R34544 MemRCol4544 MemRCol4644 1000.000000
R34545 MemRCol4545 MemRCol4645 1000.000000
R34546 MemRCol4546 MemRCol4646 1000.000000
R34547 MemRCol4547 MemRCol4647 1000.000000
R34548 MemRCol4548 MemRCol4648 1000.000000
R34549 MemRCol4549 MemRCol4649 1000.000000
R34550 MemRCol4550 MemRCol4650 1000.000000
R3461 MemRCol461 MemRCol471 1000.000000
R3462 MemRCol462 MemRCol472 1000.000000
R3463 MemRCol463 MemRCol473 1000.000000
R3464 MemRCol464 MemRCol474 1000.000000
R3465 MemRCol465 MemRCol475 1000.000000
R3466 MemRCol466 MemRCol476 1000.000000
R3467 MemRCol467 MemRCol477 1000.000000
R3468 MemRCol468 MemRCol478 1000.000000
R3469 MemRCol469 MemRCol479 1000.000000
R34610 MemRCol4610 MemRCol4710 1000.000000
R34611 MemRCol4611 MemRCol4711 1000.000000
R34612 MemRCol4612 MemRCol4712 1000.000000
R34613 MemRCol4613 MemRCol4713 1000.000000
R34614 MemRCol4614 MemRCol4714 1000.000000
R34615 MemRCol4615 MemRCol4715 1000.000000
R34616 MemRCol4616 MemRCol4716 1000.000000
R34617 MemRCol4617 MemRCol4717 1000.000000
R34618 MemRCol4618 MemRCol4718 1000.000000
R34619 MemRCol4619 MemRCol4719 1000.000000
R34620 MemRCol4620 MemRCol4720 1000.000000
R34621 MemRCol4621 MemRCol4721 1000.000000
R34622 MemRCol4622 MemRCol4722 1000.000000
R34623 MemRCol4623 MemRCol4723 1000.000000
R34624 MemRCol4624 MemRCol4724 1000.000000
R34625 MemRCol4625 MemRCol4725 1000.000000
R34626 MemRCol4626 MemRCol4726 1000.000000
R34627 MemRCol4627 MemRCol4727 1000.000000
R34628 MemRCol4628 MemRCol4728 1000.000000
R34629 MemRCol4629 MemRCol4729 1000.000000
R34630 MemRCol4630 MemRCol4730 1000.000000
R34631 MemRCol4631 MemRCol4731 1000.000000
R34632 MemRCol4632 MemRCol4732 1000.000000
R34633 MemRCol4633 MemRCol4733 1000.000000
R34634 MemRCol4634 MemRCol4734 1000.000000
R34635 MemRCol4635 MemRCol4735 1000.000000
R34636 MemRCol4636 MemRCol4736 1000.000000
R34637 MemRCol4637 MemRCol4737 1000.000000
R34638 MemRCol4638 MemRCol4738 1000.000000
R34639 MemRCol4639 MemRCol4739 1000.000000
R34640 MemRCol4640 MemRCol4740 1000.000000
R34641 MemRCol4641 MemRCol4741 1000.000000
R34642 MemRCol4642 MemRCol4742 1000.000000
R34643 MemRCol4643 MemRCol4743 1000.000000
R34644 MemRCol4644 MemRCol4744 1000.000000
R34645 MemRCol4645 MemRCol4745 1000.000000
R34646 MemRCol4646 MemRCol4746 1000.000000
R34647 MemRCol4647 MemRCol4747 1000.000000
R34648 MemRCol4648 MemRCol4748 1000.000000
R34649 MemRCol4649 MemRCol4749 1000.000000
R34650 MemRCol4650 MemRCol4750 1000.000000
R3471 MemRCol471 MemRCol481 1000.000000
R3472 MemRCol472 MemRCol482 1000.000000
R3473 MemRCol473 MemRCol483 1000.000000
R3474 MemRCol474 MemRCol484 1000.000000
R3475 MemRCol475 MemRCol485 1000.000000
R3476 MemRCol476 MemRCol486 1000.000000
R3477 MemRCol477 MemRCol487 1000.000000
R3478 MemRCol478 MemRCol488 1000.000000
R3479 MemRCol479 MemRCol489 1000.000000
R34710 MemRCol4710 MemRCol4810 1000.000000
R34711 MemRCol4711 MemRCol4811 1000.000000
R34712 MemRCol4712 MemRCol4812 1000.000000
R34713 MemRCol4713 MemRCol4813 1000.000000
R34714 MemRCol4714 MemRCol4814 1000.000000
R34715 MemRCol4715 MemRCol4815 1000.000000
R34716 MemRCol4716 MemRCol4816 1000.000000
R34717 MemRCol4717 MemRCol4817 1000.000000
R34718 MemRCol4718 MemRCol4818 1000.000000
R34719 MemRCol4719 MemRCol4819 1000.000000
R34720 MemRCol4720 MemRCol4820 1000.000000
R34721 MemRCol4721 MemRCol4821 1000.000000
R34722 MemRCol4722 MemRCol4822 1000.000000
R34723 MemRCol4723 MemRCol4823 1000.000000
R34724 MemRCol4724 MemRCol4824 1000.000000
R34725 MemRCol4725 MemRCol4825 1000.000000
R34726 MemRCol4726 MemRCol4826 1000.000000
R34727 MemRCol4727 MemRCol4827 1000.000000
R34728 MemRCol4728 MemRCol4828 1000.000000
R34729 MemRCol4729 MemRCol4829 1000.000000
R34730 MemRCol4730 MemRCol4830 1000.000000
R34731 MemRCol4731 MemRCol4831 1000.000000
R34732 MemRCol4732 MemRCol4832 1000.000000
R34733 MemRCol4733 MemRCol4833 1000.000000
R34734 MemRCol4734 MemRCol4834 1000.000000
R34735 MemRCol4735 MemRCol4835 1000.000000
R34736 MemRCol4736 MemRCol4836 1000.000000
R34737 MemRCol4737 MemRCol4837 1000.000000
R34738 MemRCol4738 MemRCol4838 1000.000000
R34739 MemRCol4739 MemRCol4839 1000.000000
R34740 MemRCol4740 MemRCol4840 1000.000000
R34741 MemRCol4741 MemRCol4841 1000.000000
R34742 MemRCol4742 MemRCol4842 1000.000000
R34743 MemRCol4743 MemRCol4843 1000.000000
R34744 MemRCol4744 MemRCol4844 1000.000000
R34745 MemRCol4745 MemRCol4845 1000.000000
R34746 MemRCol4746 MemRCol4846 1000.000000
R34747 MemRCol4747 MemRCol4847 1000.000000
R34748 MemRCol4748 MemRCol4848 1000.000000
R34749 MemRCol4749 MemRCol4849 1000.000000
R34750 MemRCol4750 MemRCol4850 1000.000000
R3481 MemRCol481 MemRCol491 1000.000000
R3482 MemRCol482 MemRCol492 1000.000000
R3483 MemRCol483 MemRCol493 1000.000000
R3484 MemRCol484 MemRCol494 1000.000000
R3485 MemRCol485 MemRCol495 1000.000000
R3486 MemRCol486 MemRCol496 1000.000000
R3487 MemRCol487 MemRCol497 1000.000000
R3488 MemRCol488 MemRCol498 1000.000000
R3489 MemRCol489 MemRCol499 1000.000000
R34810 MemRCol4810 MemRCol4910 1000.000000
R34811 MemRCol4811 MemRCol4911 1000.000000
R34812 MemRCol4812 MemRCol4912 1000.000000
R34813 MemRCol4813 MemRCol4913 1000.000000
R34814 MemRCol4814 MemRCol4914 1000.000000
R34815 MemRCol4815 MemRCol4915 1000.000000
R34816 MemRCol4816 MemRCol4916 1000.000000
R34817 MemRCol4817 MemRCol4917 1000.000000
R34818 MemRCol4818 MemRCol4918 1000.000000
R34819 MemRCol4819 MemRCol4919 1000.000000
R34820 MemRCol4820 MemRCol4920 1000.000000
R34821 MemRCol4821 MemRCol4921 1000.000000
R34822 MemRCol4822 MemRCol4922 1000.000000
R34823 MemRCol4823 MemRCol4923 1000.000000
R34824 MemRCol4824 MemRCol4924 1000.000000
R34825 MemRCol4825 MemRCol4925 1000.000000
R34826 MemRCol4826 MemRCol4926 1000.000000
R34827 MemRCol4827 MemRCol4927 1000.000000
R34828 MemRCol4828 MemRCol4928 1000.000000
R34829 MemRCol4829 MemRCol4929 1000.000000
R34830 MemRCol4830 MemRCol4930 1000.000000
R34831 MemRCol4831 MemRCol4931 1000.000000
R34832 MemRCol4832 MemRCol4932 1000.000000
R34833 MemRCol4833 MemRCol4933 1000.000000
R34834 MemRCol4834 MemRCol4934 1000.000000
R34835 MemRCol4835 MemRCol4935 1000.000000
R34836 MemRCol4836 MemRCol4936 1000.000000
R34837 MemRCol4837 MemRCol4937 1000.000000
R34838 MemRCol4838 MemRCol4938 1000.000000
R34839 MemRCol4839 MemRCol4939 1000.000000
R34840 MemRCol4840 MemRCol4940 1000.000000
R34841 MemRCol4841 MemRCol4941 1000.000000
R34842 MemRCol4842 MemRCol4942 1000.000000
R34843 MemRCol4843 MemRCol4943 1000.000000
R34844 MemRCol4844 MemRCol4944 1000.000000
R34845 MemRCol4845 MemRCol4945 1000.000000
R34846 MemRCol4846 MemRCol4946 1000.000000
R34847 MemRCol4847 MemRCol4947 1000.000000
R34848 MemRCol4848 MemRCol4948 1000.000000
R34849 MemRCol4849 MemRCol4949 1000.000000
R34850 MemRCol4850 MemRCol4950 1000.000000
R3491 MemRCol491 MemRCol501 1000.000000
R3492 MemRCol492 MemRCol502 1000.000000
R3493 MemRCol493 MemRCol503 1000.000000
R3494 MemRCol494 MemRCol504 1000.000000
R3495 MemRCol495 MemRCol505 1000.000000
R3496 MemRCol496 MemRCol506 1000.000000
R3497 MemRCol497 MemRCol507 1000.000000
R3498 MemRCol498 MemRCol508 1000.000000
R3499 MemRCol499 MemRCol509 1000.000000
R34910 MemRCol4910 MemRCol5010 1000.000000
R34911 MemRCol4911 MemRCol5011 1000.000000
R34912 MemRCol4912 MemRCol5012 1000.000000
R34913 MemRCol4913 MemRCol5013 1000.000000
R34914 MemRCol4914 MemRCol5014 1000.000000
R34915 MemRCol4915 MemRCol5015 1000.000000
R34916 MemRCol4916 MemRCol5016 1000.000000
R34917 MemRCol4917 MemRCol5017 1000.000000
R34918 MemRCol4918 MemRCol5018 1000.000000
R34919 MemRCol4919 MemRCol5019 1000.000000
R34920 MemRCol4920 MemRCol5020 1000.000000
R34921 MemRCol4921 MemRCol5021 1000.000000
R34922 MemRCol4922 MemRCol5022 1000.000000
R34923 MemRCol4923 MemRCol5023 1000.000000
R34924 MemRCol4924 MemRCol5024 1000.000000
R34925 MemRCol4925 MemRCol5025 1000.000000
R34926 MemRCol4926 MemRCol5026 1000.000000
R34927 MemRCol4927 MemRCol5027 1000.000000
R34928 MemRCol4928 MemRCol5028 1000.000000
R34929 MemRCol4929 MemRCol5029 1000.000000
R34930 MemRCol4930 MemRCol5030 1000.000000
R34931 MemRCol4931 MemRCol5031 1000.000000
R34932 MemRCol4932 MemRCol5032 1000.000000
R34933 MemRCol4933 MemRCol5033 1000.000000
R34934 MemRCol4934 MemRCol5034 1000.000000
R34935 MemRCol4935 MemRCol5035 1000.000000
R34936 MemRCol4936 MemRCol5036 1000.000000
R34937 MemRCol4937 MemRCol5037 1000.000000
R34938 MemRCol4938 MemRCol5038 1000.000000
R34939 MemRCol4939 MemRCol5039 1000.000000
R34940 MemRCol4940 MemRCol5040 1000.000000
R34941 MemRCol4941 MemRCol5041 1000.000000
R34942 MemRCol4942 MemRCol5042 1000.000000
R34943 MemRCol4943 MemRCol5043 1000.000000
R34944 MemRCol4944 MemRCol5044 1000.000000
R34945 MemRCol4945 MemRCol5045 1000.000000
R34946 MemRCol4946 MemRCol5046 1000.000000
R34947 MemRCol4947 MemRCol5047 1000.000000
R34948 MemRCol4948 MemRCol5048 1000.000000
R34949 MemRCol4949 MemRCol5049 1000.000000
R34950 MemRCol4950 MemRCol5050 1000.000000
R3501 MemRCol501 MemRCol511 1000.000000
R3502 MemRCol502 MemRCol512 1000.000000
R3503 MemRCol503 MemRCol513 1000.000000
R3504 MemRCol504 MemRCol514 1000.000000
R3505 MemRCol505 MemRCol515 1000.000000
R3506 MemRCol506 MemRCol516 1000.000000
R3507 MemRCol507 MemRCol517 1000.000000
R3508 MemRCol508 MemRCol518 1000.000000
R3509 MemRCol509 MemRCol519 1000.000000
R35010 MemRCol5010 MemRCol5110 1000.000000
R35011 MemRCol5011 MemRCol5111 1000.000000
R35012 MemRCol5012 MemRCol5112 1000.000000
R35013 MemRCol5013 MemRCol5113 1000.000000
R35014 MemRCol5014 MemRCol5114 1000.000000
R35015 MemRCol5015 MemRCol5115 1000.000000
R35016 MemRCol5016 MemRCol5116 1000.000000
R35017 MemRCol5017 MemRCol5117 1000.000000
R35018 MemRCol5018 MemRCol5118 1000.000000
R35019 MemRCol5019 MemRCol5119 1000.000000
R35020 MemRCol5020 MemRCol5120 1000.000000
R35021 MemRCol5021 MemRCol5121 1000.000000
R35022 MemRCol5022 MemRCol5122 1000.000000
R35023 MemRCol5023 MemRCol5123 1000.000000
R35024 MemRCol5024 MemRCol5124 1000.000000
R35025 MemRCol5025 MemRCol5125 1000.000000
R35026 MemRCol5026 MemRCol5126 1000.000000
R35027 MemRCol5027 MemRCol5127 1000.000000
R35028 MemRCol5028 MemRCol5128 1000.000000
R35029 MemRCol5029 MemRCol5129 1000.000000
R35030 MemRCol5030 MemRCol5130 1000.000000
R35031 MemRCol5031 MemRCol5131 1000.000000
R35032 MemRCol5032 MemRCol5132 1000.000000
R35033 MemRCol5033 MemRCol5133 1000.000000
R35034 MemRCol5034 MemRCol5134 1000.000000
R35035 MemRCol5035 MemRCol5135 1000.000000
R35036 MemRCol5036 MemRCol5136 1000.000000
R35037 MemRCol5037 MemRCol5137 1000.000000
R35038 MemRCol5038 MemRCol5138 1000.000000
R35039 MemRCol5039 MemRCol5139 1000.000000
R35040 MemRCol5040 MemRCol5140 1000.000000
R35041 MemRCol5041 MemRCol5141 1000.000000
R35042 MemRCol5042 MemRCol5142 1000.000000
R35043 MemRCol5043 MemRCol5143 1000.000000
R35044 MemRCol5044 MemRCol5144 1000.000000
R35045 MemRCol5045 MemRCol5145 1000.000000
R35046 MemRCol5046 MemRCol5146 1000.000000
R35047 MemRCol5047 MemRCol5147 1000.000000
R35048 MemRCol5048 MemRCol5148 1000.000000
R35049 MemRCol5049 MemRCol5149 1000.000000
R35050 MemRCol5050 MemRCol5150 1000.000000

*Column 'Ammeter' Resistances
R51 MemRCol511 0 0.000000001000
R52 MemRCol512 0 0.000000001000
R53 MemRCol513 0 0.000000001000
R54 MemRCol514 0 0.000000001000
R55 MemRCol515 0 0.000000001000
R56 MemRCol516 0 0.000000001000
R57 MemRCol517 0 0.000000001000
R58 MemRCol518 0 0.000000001000
R59 MemRCol519 0 0.000000001000
R510 MemRCol5110 0 0.000000001000
R511 MemRCol5111 0 0.000000001000
R512 MemRCol5112 0 0.000000001000
R513 MemRCol5113 0 0.000000001000
R514 MemRCol5114 0 0.000000001000
R515 MemRCol5115 0 0.000000001000
R516 MemRCol5116 0 0.000000001000
R517 MemRCol5117 0 0.000000001000
R518 MemRCol5118 0 0.000000001000
R519 MemRCol5119 0 0.000000001000
R520 MemRCol5120 0 0.000000001000
R521 MemRCol5121 0 0.000000001000
R522 MemRCol5122 0 0.000000001000
R523 MemRCol5123 0 0.000000001000
R524 MemRCol5124 0 0.000000001000
R525 MemRCol5125 0 0.000000001000
R526 MemRCol5126 0 0.000000001000
R527 MemRCol5127 0 0.000000001000
R528 MemRCol5128 0 0.000000001000
R529 MemRCol5129 0 0.000000001000
R530 MemRCol5130 0 0.000000001000
R531 MemRCol5131 0 0.000000001000
R532 MemRCol5132 0 0.000000001000
R533 MemRCol5133 0 0.000000001000
R534 MemRCol5134 0 0.000000001000
R535 MemRCol5135 0 0.000000001000
R536 MemRCol5136 0 0.000000001000
R537 MemRCol5137 0 0.000000001000
R538 MemRCol5138 0 0.000000001000
R539 MemRCol5139 0 0.000000001000
R540 MemRCol5140 0 0.000000001000
R541 MemRCol5141 0 0.000000001000
R542 MemRCol5142 0 0.000000001000
R543 MemRCol5143 0 0.000000001000
R544 MemRCol5144 0 0.000000001000
R545 MemRCol5145 0 0.000000001000
R546 MemRCol5146 0 0.000000001000
R547 MemRCol5147 0 0.000000001000
R548 MemRCol5148 0 0.000000001000
R549 MemRCol5149 0 0.000000001000
R550 MemRCol5150 0 0.000000001000

*Spice Directives
.op
*.backanno
.end
