*mat_array.cir

*Row Voltage Sources
V1 RowC_1 0 -5.000000
V3 RowC_2 0 -5.000000
V6 RowC_3 0 -5.000000

*Row Current Sources
I1 I_1 0 -0.000000
I3 I_3 0 -0.000000
I6 I_6 0 -0.000000

*Row 'Ammeter' Resistances
R41 RowC_1 MemRRow4 0.000000001000
R42 RowC_2 MemRRow7 0.000000001000
R43 RowC_3 MemRRow11 0.000000001000

*Memristor Resistances
R14 MemRRow4 MemRCol4 100.000000
R18 MemRRow8 MemRCol8 3400.000000
R113 MemRRow13 MemRCol13 3400.000000
R17 MemRRow7 MemRCol7 10000.000000
R112 MemRRow12 MemRCol12 3400.000000
R118 MemRRow18 MemRCol18 3400.000000
R111 MemRRow11 MemRCol11 3400.000000
R117 MemRRow17 MemRCol17 6700.000000
R124 MemRRow24 MemRCol24 3400.000000

*Line Row Resistances
R24 MemRRow4 MemRRow8 0.001000
R28 MemRRow8 MemRRow13 0.001000
R213 MemRRow13 MemRRow19 0.001000
R27 MemRRow7 MemRRow12 0.001000
R212 MemRRow12 MemRRow18 0.001000
R218 MemRRow18 MemRRow25 0.001000
R211 MemRRow11 MemRRow17 0.001000
R217 MemRRow17 MemRRow24 0.001000
R224 MemRRow24 MemRRow32 0.001000

*Line Column Resistances
R34 MemRCol4 MemRCol7 10000.000000
R38 MemRCol8 MemRCol12 10000.000000
R313 MemRCol13 MemRCol18 10000.000000
R37 MemRCol7 MemRCol11 10000.000000
R312 MemRCol12 MemRCol17 10000.000000
R318 MemRCol18 MemRCol24 10000.000000
R311 MemRCol11 MemRCol16 10000.000000
R317 MemRCol17 MemRCol23 10000.000000
R324 MemRCol24 MemRCol31 10000.000000

*Column 'Ammeter' Resistances
R51 MemRCol16 ColC_1 0.000000001000
R52 MemRCol23 ColC_2 0.000000001000
R53 MemRCol31 ColC_3 0.000000001000

*Column Voltage Sources
V2 ColC_1 0 0.000000
V5 ColC_2 0 0.000000
V9 ColC_3 0 0.000000

*Column Current Sources
I2 I_2 0 -0.000000
I5 I_5 0 -0.000000
I9 I_9 0 -0.000000

*Spice Directives
.op
*.backanno
.end
