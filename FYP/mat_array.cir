*mat_array.cir

*Row Voltage Sources
V1 RowC_1 0 5.000000
V3 RowC_2 0 0.000000
V6 RowC_3 0 0.000000
V10 RowC_4 0 0.000000
V15 RowC_5 0 0.000000
V21 RowC_6 0 0.000000
V28 RowC_7 0 0.000000
V36 RowC_8 0 0.000000
V45 RowC_9 0 0.000000
V55 RowC_10 0 0.000000
V66 RowC_11 0 0.000000
V78 RowC_12 0 0.000000
V91 RowC_13 0 0.000000
V105 RowC_14 0 0.000000
V120 RowC_15 0 0.000000
V136 RowC_16 0 0.000000
V153 RowC_17 0 0.000000
V171 RowC_18 0 0.000000
V190 RowC_19 0 0.000000
V210 RowC_20 0 0.000000
V231 RowC_21 0 0.000000
V253 RowC_22 0 0.000000
V276 RowC_23 0 0.000000
V300 RowC_24 0 0.000000
V325 RowC_25 0 0.000000
V351 RowC_26 0 0.000000
V378 RowC_27 0 0.000000
V406 RowC_28 0 0.000000
V435 RowC_29 0 0.000000
V465 RowC_30 0 0.000000
V496 RowC_31 0 0.000000
V528 RowC_32 0 0.000000

*Row Current Sources
I1 I_1 0 -0.000000
I3 I_3 0 -0.000000
I6 I_6 0 -0.000000
I10 I_10 0 -0.000000
I15 I_15 0 -0.000000
I21 I_21 0 -0.000000
I28 I_28 0 -0.000000
I36 I_36 0 -0.000000
I45 I_45 0 -0.000000
I55 I_55 0 -0.000000
I66 I_66 0 -0.000000
I78 I_78 0 -0.000000
I91 I_91 0 -0.000000
I105 I_105 0 -0.000000
I120 I_120 0 -0.000000
I136 I_136 0 -0.000000
I153 I_153 0 -0.000000
I171 I_171 0 -0.000000
I190 I_190 0 -0.000000
I210 I_210 0 -0.000000
I231 I_231 0 -0.000000
I253 I_253 0 -0.000000
I276 I_276 0 -0.000000
I300 I_300 0 -0.000000
I325 I_325 0 -0.000000
I351 I_351 0 -0.000000
I378 I_378 0 -0.000000
I406 I_406 0 -0.000000
I435 I_435 0 -0.000000
I465 I_465 0 -0.000000
I496 I_496 0 -0.000000
I528 I_528 0 -0.000000

*Row 'Ammeter' Resistances
R41 RowC_1 MemRRow4 0.000000001000
R42 RowC_2 MemRRow7 0.000000001000
R43 RowC_3 MemRRow11 0.000000001000
R44 RowC_4 MemRRow16 0.000000001000
R45 RowC_5 MemRRow22 0.000000001000
R46 RowC_6 MemRRow29 0.000000001000
R47 RowC_7 MemRRow37 0.000000001000
R48 RowC_8 MemRRow46 0.000000001000
R49 RowC_9 MemRRow56 0.000000001000
R410 RowC_10 MemRRow67 0.000000001000
R411 RowC_11 MemRRow79 0.000000001000
R412 RowC_12 MemRRow92 0.000000001000
R413 RowC_13 MemRRow106 0.000000001000
R414 RowC_14 MemRRow121 0.000000001000
R415 RowC_15 MemRRow137 0.000000001000
R416 RowC_16 MemRRow154 0.000000001000
R417 RowC_17 MemRRow172 0.000000001000
R418 RowC_18 MemRRow191 0.000000001000
R419 RowC_19 MemRRow211 0.000000001000
R420 RowC_20 MemRRow232 0.000000001000
R421 RowC_21 MemRRow254 0.000000001000
R422 RowC_22 MemRRow277 0.000000001000
R423 RowC_23 MemRRow301 0.000000001000
R424 RowC_24 MemRRow326 0.000000001000
R425 RowC_25 MemRRow352 0.000000001000
R426 RowC_26 MemRRow379 0.000000001000
R427 RowC_27 MemRRow407 0.000000001000
R428 RowC_28 MemRRow436 0.000000001000
R429 RowC_29 MemRRow466 0.000000001000
R430 RowC_30 MemRRow497 0.000000001000
R431 RowC_31 MemRRow529 0.000000001000
R432 RowC_32 MemRRow562 0.000000001000

*Memristor Resistances
R14 MemRRow4 MemRCol4 10000.000000
R18 MemRRow8 MemRCol8 10000.000000
R113 MemRRow13 MemRCol13 10000.000000
R119 MemRRow19 MemRCol19 10000.000000
R126 MemRRow26 MemRCol26 10000.000000
R134 MemRRow34 MemRCol34 10000.000000
R143 MemRRow43 MemRCol43 10000.000000
R153 MemRRow53 MemRCol53 10000.000000
R164 MemRRow64 MemRCol64 10000.000000
R176 MemRRow76 MemRCol76 10000.000000
R189 MemRRow89 MemRCol89 10000.000000
R1103 MemRRow103 MemRCol103 10000.000000
R1118 MemRRow118 MemRCol118 10000.000000
R1134 MemRRow134 MemRCol134 10000.000000
R1151 MemRRow151 MemRCol151 10000.000000
R1169 MemRRow169 MemRCol169 10000.000000
R1188 MemRRow188 MemRCol188 10000.000000
R1208 MemRRow208 MemRCol208 10000.000000
R1229 MemRRow229 MemRCol229 10000.000000
R1251 MemRRow251 MemRCol251 10000.000000
R1274 MemRRow274 MemRCol274 10000.000000
R1298 MemRRow298 MemRCol298 10000.000000
R1323 MemRRow323 MemRCol323 10000.000000
R1349 MemRRow349 MemRCol349 10000.000000
R1376 MemRRow376 MemRCol376 10000.000000
R1404 MemRRow404 MemRCol404 10000.000000
R1433 MemRRow433 MemRCol433 10000.000000
R1463 MemRRow463 MemRCol463 10000.000000
R1494 MemRRow494 MemRCol494 10000.000000
R1526 MemRRow526 MemRCol526 10000.000000
R1559 MemRRow559 MemRCol559 10000.000000
R1593 MemRRow593 MemRCol593 10000.000000
R17 MemRRow7 MemRCol7 10000.000000
R112 MemRRow12 MemRCol12 10000.000000
R118 MemRRow18 MemRCol18 10000.000000
R125 MemRRow25 MemRCol25 10000.000000
R133 MemRRow33 MemRCol33 10000.000000
R142 MemRRow42 MemRCol42 10000.000000
R152 MemRRow52 MemRCol52 10000.000000
R163 MemRRow63 MemRCol63 10000.000000
R175 MemRRow75 MemRCol75 10000.000000
R188 MemRRow88 MemRCol88 10000.000000
R1102 MemRRow102 MemRCol102 10000.000000
R1117 MemRRow117 MemRCol117 10000.000000
R1133 MemRRow133 MemRCol133 10000.000000
R1150 MemRRow150 MemRCol150 10000.000000
R1168 MemRRow168 MemRCol168 10000.000000
R1187 MemRRow187 MemRCol187 10000.000000
R1207 MemRRow207 MemRCol207 10000.000000
R1228 MemRRow228 MemRCol228 10000.000000
R1250 MemRRow250 MemRCol250 10000.000000
R1273 MemRRow273 MemRCol273 10000.000000
R1297 MemRRow297 MemRCol297 10000.000000
R1322 MemRRow322 MemRCol322 10000.000000
R1348 MemRRow348 MemRCol348 10000.000000
R1375 MemRRow375 MemRCol375 10000.000000
R1403 MemRRow403 MemRCol403 10000.000000
R1432 MemRRow432 MemRCol432 10000.000000
R1462 MemRRow462 MemRCol462 10000.000000
R1493 MemRRow493 MemRCol493 10000.000000
R1525 MemRRow525 MemRCol525 10000.000000
R1558 MemRRow558 MemRCol558 10000.000000
R1592 MemRRow592 MemRCol592 10000.000000
R1627 MemRRow627 MemRCol627 10000.000000
R111 MemRRow11 MemRCol11 10000.000000
R117 MemRRow17 MemRCol17 10000.000000
R124 MemRRow24 MemRCol24 10000.000000
R132 MemRRow32 MemRCol32 10000.000000
R141 MemRRow41 MemRCol41 10000.000000
R151 MemRRow51 MemRCol51 10000.000000
R162 MemRRow62 MemRCol62 10000.000000
R174 MemRRow74 MemRCol74 10000.000000
R187 MemRRow87 MemRCol87 10000.000000
R1101 MemRRow101 MemRCol101 10000.000000
R1116 MemRRow116 MemRCol116 10000.000000
R1132 MemRRow132 MemRCol132 10000.000000
R1149 MemRRow149 MemRCol149 10000.000000
R1167 MemRRow167 MemRCol167 10000.000000
R1186 MemRRow186 MemRCol186 10000.000000
R1206 MemRRow206 MemRCol206 10000.000000
R1227 MemRRow227 MemRCol227 10000.000000
R1249 MemRRow249 MemRCol249 10000.000000
R1272 MemRRow272 MemRCol272 10000.000000
R1296 MemRRow296 MemRCol296 10000.000000
R1321 MemRRow321 MemRCol321 10000.000000
R1347 MemRRow347 MemRCol347 10000.000000
R1374 MemRRow374 MemRCol374 10000.000000
R1402 MemRRow402 MemRCol402 10000.000000
R1431 MemRRow431 MemRCol431 10000.000000
R1461 MemRRow461 MemRCol461 10000.000000
R1492 MemRRow492 MemRCol492 10000.000000
R1524 MemRRow524 MemRCol524 10000.000000
R1557 MemRRow557 MemRCol557 10000.000000
R1591 MemRRow591 MemRCol591 10000.000000
R1626 MemRRow626 MemRCol626 10000.000000
R1662 MemRRow662 MemRCol662 10000.000000
R116 MemRRow16 MemRCol16 10000.000000
R123 MemRRow23 MemRCol23 10000.000000
R131 MemRRow31 MemRCol31 10000.000000
R140 MemRRow40 MemRCol40 10000.000000
R150 MemRRow50 MemRCol50 10000.000000
R161 MemRRow61 MemRCol61 10000.000000
R173 MemRRow73 MemRCol73 10000.000000
R186 MemRRow86 MemRCol86 10000.000000
R1100 MemRRow100 MemRCol100 10000.000000
R1115 MemRRow115 MemRCol115 10000.000000
R1131 MemRRow131 MemRCol131 10000.000000
R1148 MemRRow148 MemRCol148 10000.000000
R1166 MemRRow166 MemRCol166 10000.000000
R1185 MemRRow185 MemRCol185 10000.000000
R1205 MemRRow205 MemRCol205 10000.000000
R1226 MemRRow226 MemRCol226 10000.000000
R1248 MemRRow248 MemRCol248 10000.000000
R1271 MemRRow271 MemRCol271 10000.000000
R1295 MemRRow295 MemRCol295 10000.000000
R1320 MemRRow320 MemRCol320 10000.000000
R1346 MemRRow346 MemRCol346 10000.000000
R1373 MemRRow373 MemRCol373 10000.000000
R1401 MemRRow401 MemRCol401 10000.000000
R1430 MemRRow430 MemRCol430 10000.000000
R1460 MemRRow460 MemRCol460 10000.000000
R1491 MemRRow491 MemRCol491 10000.000000
R1523 MemRRow523 MemRCol523 10000.000000
R1556 MemRRow556 MemRCol556 10000.000000
R1590 MemRRow590 MemRCol590 10000.000000
R1625 MemRRow625 MemRCol625 10000.000000
R1661 MemRRow661 MemRCol661 10000.000000
R1698 MemRRow698 MemRCol698 10000.000000
R122 MemRRow22 MemRCol22 10000.000000
R130 MemRRow30 MemRCol30 10000.000000
R139 MemRRow39 MemRCol39 10000.000000
R149 MemRRow49 MemRCol49 10000.000000
R160 MemRRow60 MemRCol60 10000.000000
R172 MemRRow72 MemRCol72 10000.000000
R185 MemRRow85 MemRCol85 10000.000000
R199 MemRRow99 MemRCol99 10000.000000
R1114 MemRRow114 MemRCol114 10000.000000
R1130 MemRRow130 MemRCol130 10000.000000
R1147 MemRRow147 MemRCol147 10000.000000
R1165 MemRRow165 MemRCol165 10000.000000
R1184 MemRRow184 MemRCol184 10000.000000
R1204 MemRRow204 MemRCol204 10000.000000
R1225 MemRRow225 MemRCol225 10000.000000
R1247 MemRRow247 MemRCol247 10000.000000
R1270 MemRRow270 MemRCol270 10000.000000
R1294 MemRRow294 MemRCol294 10000.000000
R1319 MemRRow319 MemRCol319 10000.000000
R1345 MemRRow345 MemRCol345 10000.000000
R1372 MemRRow372 MemRCol372 10000.000000
R1400 MemRRow400 MemRCol400 10000.000000
R1429 MemRRow429 MemRCol429 10000.000000
R1459 MemRRow459 MemRCol459 10000.000000
R1490 MemRRow490 MemRCol490 10000.000000
R1522 MemRRow522 MemRCol522 10000.000000
R1555 MemRRow555 MemRCol555 10000.000000
R1589 MemRRow589 MemRCol589 10000.000000
R1624 MemRRow624 MemRCol624 10000.000000
R1660 MemRRow660 MemRCol660 10000.000000
R1697 MemRRow697 MemRCol697 10000.000000
R1735 MemRRow735 MemRCol735 10000.000000
R129 MemRRow29 MemRCol29 10000.000000
R138 MemRRow38 MemRCol38 10000.000000
R148 MemRRow48 MemRCol48 10000.000000
R159 MemRRow59 MemRCol59 10000.000000
R171 MemRRow71 MemRCol71 10000.000000
R184 MemRRow84 MemRCol84 10000.000000
R198 MemRRow98 MemRCol98 10000.000000
R1113 MemRRow113 MemRCol113 10000.000000
R1129 MemRRow129 MemRCol129 10000.000000
R1146 MemRRow146 MemRCol146 10000.000000
R1164 MemRRow164 MemRCol164 10000.000000
R1183 MemRRow183 MemRCol183 10000.000000
R1203 MemRRow203 MemRCol203 10000.000000
R1224 MemRRow224 MemRCol224 10000.000000
R1246 MemRRow246 MemRCol246 10000.000000
R1269 MemRRow269 MemRCol269 10000.000000
R1293 MemRRow293 MemRCol293 10000.000000
R1318 MemRRow318 MemRCol318 10000.000000
R1344 MemRRow344 MemRCol344 10000.000000
R1371 MemRRow371 MemRCol371 10000.000000
R1399 MemRRow399 MemRCol399 10000.000000
R1428 MemRRow428 MemRCol428 10000.000000
R1458 MemRRow458 MemRCol458 10000.000000
R1489 MemRRow489 MemRCol489 10000.000000
R1521 MemRRow521 MemRCol521 10000.000000
R1554 MemRRow554 MemRCol554 10000.000000
R1588 MemRRow588 MemRCol588 10000.000000
R1623 MemRRow623 MemRCol623 10000.000000
R1659 MemRRow659 MemRCol659 10000.000000
R1696 MemRRow696 MemRCol696 10000.000000
R1734 MemRRow734 MemRCol734 10000.000000
R1773 MemRRow773 MemRCol773 10000.000000
R137 MemRRow37 MemRCol37 10000.000000
R147 MemRRow47 MemRCol47 10000.000000
R158 MemRRow58 MemRCol58 10000.000000
R170 MemRRow70 MemRCol70 10000.000000
R183 MemRRow83 MemRCol83 10000.000000
R197 MemRRow97 MemRCol97 10000.000000
R1112 MemRRow112 MemRCol112 10000.000000
R1128 MemRRow128 MemRCol128 10000.000000
R1145 MemRRow145 MemRCol145 10000.000000
R1163 MemRRow163 MemRCol163 10000.000000
R1182 MemRRow182 MemRCol182 10000.000000
R1202 MemRRow202 MemRCol202 10000.000000
R1223 MemRRow223 MemRCol223 10000.000000
R1245 MemRRow245 MemRCol245 10000.000000
R1268 MemRRow268 MemRCol268 10000.000000
R1292 MemRRow292 MemRCol292 10000.000000
R1317 MemRRow317 MemRCol317 10000.000000
R1343 MemRRow343 MemRCol343 10000.000000
R1370 MemRRow370 MemRCol370 10000.000000
R1398 MemRRow398 MemRCol398 10000.000000
R1427 MemRRow427 MemRCol427 10000.000000
R1457 MemRRow457 MemRCol457 10000.000000
R1488 MemRRow488 MemRCol488 10000.000000
R1520 MemRRow520 MemRCol520 10000.000000
R1553 MemRRow553 MemRCol553 10000.000000
R1587 MemRRow587 MemRCol587 10000.000000
R1622 MemRRow622 MemRCol622 10000.000000
R1658 MemRRow658 MemRCol658 10000.000000
R1695 MemRRow695 MemRCol695 10000.000000
R1733 MemRRow733 MemRCol733 10000.000000
R1772 MemRRow772 MemRCol772 10000.000000
R1812 MemRRow812 MemRCol812 10000.000000
R146 MemRRow46 MemRCol46 10000.000000
R157 MemRRow57 MemRCol57 10000.000000
R169 MemRRow69 MemRCol69 10000.000000
R182 MemRRow82 MemRCol82 10000.000000
R196 MemRRow96 MemRCol96 10000.000000
R1111 MemRRow111 MemRCol111 10000.000000
R1127 MemRRow127 MemRCol127 10000.000000
R1144 MemRRow144 MemRCol144 10000.000000
R1162 MemRRow162 MemRCol162 10000.000000
R1181 MemRRow181 MemRCol181 10000.000000
R1201 MemRRow201 MemRCol201 10000.000000
R1222 MemRRow222 MemRCol222 10000.000000
R1244 MemRRow244 MemRCol244 10000.000000
R1267 MemRRow267 MemRCol267 10000.000000
R1291 MemRRow291 MemRCol291 10000.000000
R1316 MemRRow316 MemRCol316 10000.000000
R1342 MemRRow342 MemRCol342 10000.000000
R1369 MemRRow369 MemRCol369 10000.000000
R1397 MemRRow397 MemRCol397 10000.000000
R1426 MemRRow426 MemRCol426 10000.000000
R1456 MemRRow456 MemRCol456 10000.000000
R1487 MemRRow487 MemRCol487 10000.000000
R1519 MemRRow519 MemRCol519 10000.000000
R1552 MemRRow552 MemRCol552 10000.000000
R1586 MemRRow586 MemRCol586 10000.000000
R1621 MemRRow621 MemRCol621 10000.000000
R1657 MemRRow657 MemRCol657 10000.000000
R1694 MemRRow694 MemRCol694 10000.000000
R1732 MemRRow732 MemRCol732 10000.000000
R1771 MemRRow771 MemRCol771 10000.000000
R1811 MemRRow811 MemRCol811 10000.000000
R1852 MemRRow852 MemRCol852 10000.000000
R156 MemRRow56 MemRCol56 10000.000000
R168 MemRRow68 MemRCol68 10000.000000
R181 MemRRow81 MemRCol81 10000.000000
R195 MemRRow95 MemRCol95 10000.000000
R1110 MemRRow110 MemRCol110 10000.000000
R1126 MemRRow126 MemRCol126 10000.000000
R1143 MemRRow143 MemRCol143 10000.000000
R1161 MemRRow161 MemRCol161 10000.000000
R1180 MemRRow180 MemRCol180 10000.000000
R1200 MemRRow200 MemRCol200 10000.000000
R1221 MemRRow221 MemRCol221 10000.000000
R1243 MemRRow243 MemRCol243 10000.000000
R1266 MemRRow266 MemRCol266 10000.000000
R1290 MemRRow290 MemRCol290 10000.000000
R1315 MemRRow315 MemRCol315 10000.000000
R1341 MemRRow341 MemRCol341 10000.000000
R1368 MemRRow368 MemRCol368 10000.000000
R1396 MemRRow396 MemRCol396 10000.000000
R1425 MemRRow425 MemRCol425 10000.000000
R1455 MemRRow455 MemRCol455 10000.000000
R1486 MemRRow486 MemRCol486 10000.000000
R1518 MemRRow518 MemRCol518 10000.000000
R1551 MemRRow551 MemRCol551 10000.000000
R1585 MemRRow585 MemRCol585 10000.000000
R1620 MemRRow620 MemRCol620 10000.000000
R1656 MemRRow656 MemRCol656 10000.000000
R1693 MemRRow693 MemRCol693 10000.000000
R1731 MemRRow731 MemRCol731 10000.000000
R1770 MemRRow770 MemRCol770 10000.000000
R1810 MemRRow810 MemRCol810 10000.000000
R1851 MemRRow851 MemRCol851 10000.000000
R1893 MemRRow893 MemRCol893 10000.000000
R167 MemRRow67 MemRCol67 10000.000000
R180 MemRRow80 MemRCol80 10000.000000
R194 MemRRow94 MemRCol94 10000.000000
R1109 MemRRow109 MemRCol109 10000.000000
R1125 MemRRow125 MemRCol125 10000.000000
R1142 MemRRow142 MemRCol142 10000.000000
R1160 MemRRow160 MemRCol160 10000.000000
R1179 MemRRow179 MemRCol179 10000.000000
R1199 MemRRow199 MemRCol199 10000.000000
R1220 MemRRow220 MemRCol220 10000.000000
R1242 MemRRow242 MemRCol242 10000.000000
R1265 MemRRow265 MemRCol265 10000.000000
R1289 MemRRow289 MemRCol289 10000.000000
R1314 MemRRow314 MemRCol314 10000.000000
R1340 MemRRow340 MemRCol340 10000.000000
R1367 MemRRow367 MemRCol367 10000.000000
R1395 MemRRow395 MemRCol395 10000.000000
R1424 MemRRow424 MemRCol424 10000.000000
R1454 MemRRow454 MemRCol454 10000.000000
R1485 MemRRow485 MemRCol485 10000.000000
R1517 MemRRow517 MemRCol517 10000.000000
R1550 MemRRow550 MemRCol550 10000.000000
R1584 MemRRow584 MemRCol584 10000.000000
R1619 MemRRow619 MemRCol619 10000.000000
R1655 MemRRow655 MemRCol655 10000.000000
R1692 MemRRow692 MemRCol692 10000.000000
R1730 MemRRow730 MemRCol730 10000.000000
R1769 MemRRow769 MemRCol769 10000.000000
R1809 MemRRow809 MemRCol809 10000.000000
R1850 MemRRow850 MemRCol850 10000.000000
R1892 MemRRow892 MemRCol892 10000.000000
R1935 MemRRow935 MemRCol935 10000.000000
R179 MemRRow79 MemRCol79 10000.000000
R193 MemRRow93 MemRCol93 10000.000000
R1108 MemRRow108 MemRCol108 10000.000000
R1124 MemRRow124 MemRCol124 10000.000000
R1141 MemRRow141 MemRCol141 10000.000000
R1159 MemRRow159 MemRCol159 10000.000000
R1178 MemRRow178 MemRCol178 10000.000000
R1198 MemRRow198 MemRCol198 10000.000000
R1219 MemRRow219 MemRCol219 10000.000000
R1241 MemRRow241 MemRCol241 10000.000000
R1264 MemRRow264 MemRCol264 10000.000000
R1288 MemRRow288 MemRCol288 10000.000000
R1313 MemRRow313 MemRCol313 10000.000000
R1339 MemRRow339 MemRCol339 10000.000000
R1366 MemRRow366 MemRCol366 10000.000000
R1394 MemRRow394 MemRCol394 10000.000000
R1423 MemRRow423 MemRCol423 10000.000000
R1453 MemRRow453 MemRCol453 10000.000000
R1484 MemRRow484 MemRCol484 10000.000000
R1516 MemRRow516 MemRCol516 10000.000000
R1549 MemRRow549 MemRCol549 10000.000000
R1583 MemRRow583 MemRCol583 10000.000000
R1618 MemRRow618 MemRCol618 10000.000000
R1654 MemRRow654 MemRCol654 10000.000000
R1691 MemRRow691 MemRCol691 10000.000000
R1729 MemRRow729 MemRCol729 10000.000000
R1768 MemRRow768 MemRCol768 10000.000000
R1808 MemRRow808 MemRCol808 10000.000000
R1849 MemRRow849 MemRCol849 10000.000000
R1891 MemRRow891 MemRCol891 10000.000000
R1934 MemRRow934 MemRCol934 10000.000000
R1978 MemRRow978 MemRCol978 10000.000000
R192 MemRRow92 MemRCol92 10000.000000
R1107 MemRRow107 MemRCol107 10000.000000
R1123 MemRRow123 MemRCol123 10000.000000
R1140 MemRRow140 MemRCol140 10000.000000
R1158 MemRRow158 MemRCol158 10000.000000
R1177 MemRRow177 MemRCol177 10000.000000
R1197 MemRRow197 MemRCol197 10000.000000
R1218 MemRRow218 MemRCol218 10000.000000
R1240 MemRRow240 MemRCol240 10000.000000
R1263 MemRRow263 MemRCol263 10000.000000
R1287 MemRRow287 MemRCol287 10000.000000
R1312 MemRRow312 MemRCol312 10000.000000
R1338 MemRRow338 MemRCol338 10000.000000
R1365 MemRRow365 MemRCol365 10000.000000
R1393 MemRRow393 MemRCol393 10000.000000
R1422 MemRRow422 MemRCol422 10000.000000
R1452 MemRRow452 MemRCol452 10000.000000
R1483 MemRRow483 MemRCol483 10000.000000
R1515 MemRRow515 MemRCol515 10000.000000
R1548 MemRRow548 MemRCol548 10000.000000
R1582 MemRRow582 MemRCol582 10000.000000
R1617 MemRRow617 MemRCol617 10000.000000
R1653 MemRRow653 MemRCol653 10000.000000
R1690 MemRRow690 MemRCol690 10000.000000
R1728 MemRRow728 MemRCol728 10000.000000
R1767 MemRRow767 MemRCol767 10000.000000
R1807 MemRRow807 MemRCol807 10000.000000
R1848 MemRRow848 MemRCol848 10000.000000
R1890 MemRRow890 MemRCol890 10000.000000
R1933 MemRRow933 MemRCol933 10000.000000
R1977 MemRRow977 MemRCol977 10000.000000
R11022 MemRRow1022 MemRCol1022 10000.000000
R1106 MemRRow106 MemRCol106 10000.000000
R1122 MemRRow122 MemRCol122 10000.000000
R1139 MemRRow139 MemRCol139 10000.000000
R1157 MemRRow157 MemRCol157 10000.000000
R1176 MemRRow176 MemRCol176 10000.000000
R1196 MemRRow196 MemRCol196 10000.000000
R1217 MemRRow217 MemRCol217 10000.000000
R1239 MemRRow239 MemRCol239 10000.000000
R1262 MemRRow262 MemRCol262 10000.000000
R1286 MemRRow286 MemRCol286 10000.000000
R1311 MemRRow311 MemRCol311 10000.000000
R1337 MemRRow337 MemRCol337 10000.000000
R1364 MemRRow364 MemRCol364 10000.000000
R1392 MemRRow392 MemRCol392 10000.000000
R1421 MemRRow421 MemRCol421 10000.000000
R1451 MemRRow451 MemRCol451 10000.000000
R1482 MemRRow482 MemRCol482 10000.000000
R1514 MemRRow514 MemRCol514 10000.000000
R1547 MemRRow547 MemRCol547 10000.000000
R1581 MemRRow581 MemRCol581 10000.000000
R1616 MemRRow616 MemRCol616 10000.000000
R1652 MemRRow652 MemRCol652 10000.000000
R1689 MemRRow689 MemRCol689 10000.000000
R1727 MemRRow727 MemRCol727 10000.000000
R1766 MemRRow766 MemRCol766 10000.000000
R1806 MemRRow806 MemRCol806 10000.000000
R1847 MemRRow847 MemRCol847 10000.000000
R1889 MemRRow889 MemRCol889 10000.000000
R1932 MemRRow932 MemRCol932 10000.000000
R1976 MemRRow976 MemRCol976 10000.000000
R11021 MemRRow1021 MemRCol1021 10000.000000
R11067 MemRRow1067 MemRCol1067 10000.000000
R1121 MemRRow121 MemRCol121 10000.000000
R1138 MemRRow138 MemRCol138 10000.000000
R1156 MemRRow156 MemRCol156 10000.000000
R1175 MemRRow175 MemRCol175 10000.000000
R1195 MemRRow195 MemRCol195 10000.000000
R1216 MemRRow216 MemRCol216 10000.000000
R1238 MemRRow238 MemRCol238 10000.000000
R1261 MemRRow261 MemRCol261 10000.000000
R1285 MemRRow285 MemRCol285 10000.000000
R1310 MemRRow310 MemRCol310 10000.000000
R1336 MemRRow336 MemRCol336 10000.000000
R1363 MemRRow363 MemRCol363 10000.000000
R1391 MemRRow391 MemRCol391 10000.000000
R1420 MemRRow420 MemRCol420 10000.000000
R1450 MemRRow450 MemRCol450 10000.000000
R1481 MemRRow481 MemRCol481 10000.000000
R1513 MemRRow513 MemRCol513 10000.000000
R1546 MemRRow546 MemRCol546 10000.000000
R1580 MemRRow580 MemRCol580 10000.000000
R1615 MemRRow615 MemRCol615 10000.000000
R1651 MemRRow651 MemRCol651 10000.000000
R1688 MemRRow688 MemRCol688 10000.000000
R1726 MemRRow726 MemRCol726 10000.000000
R1765 MemRRow765 MemRCol765 10000.000000
R1805 MemRRow805 MemRCol805 10000.000000
R1846 MemRRow846 MemRCol846 10000.000000
R1888 MemRRow888 MemRCol888 10000.000000
R1931 MemRRow931 MemRCol931 10000.000000
R1975 MemRRow975 MemRCol975 10000.000000
R11020 MemRRow1020 MemRCol1020 10000.000000
R11066 MemRRow1066 MemRCol1066 10000.000000
R11113 MemRRow1113 MemRCol1113 10000.000000
R1137 MemRRow137 MemRCol137 10000.000000
R1155 MemRRow155 MemRCol155 10000.000000
R1174 MemRRow174 MemRCol174 10000.000000
R1194 MemRRow194 MemRCol194 10000.000000
R1215 MemRRow215 MemRCol215 10000.000000
R1237 MemRRow237 MemRCol237 10000.000000
R1260 MemRRow260 MemRCol260 10000.000000
R1284 MemRRow284 MemRCol284 10000.000000
R1309 MemRRow309 MemRCol309 10000.000000
R1335 MemRRow335 MemRCol335 10000.000000
R1362 MemRRow362 MemRCol362 10000.000000
R1390 MemRRow390 MemRCol390 10000.000000
R1419 MemRRow419 MemRCol419 10000.000000
R1449 MemRRow449 MemRCol449 10000.000000
R1480 MemRRow480 MemRCol480 10000.000000
R1512 MemRRow512 MemRCol512 10000.000000
R1545 MemRRow545 MemRCol545 10000.000000
R1579 MemRRow579 MemRCol579 10000.000000
R1614 MemRRow614 MemRCol614 10000.000000
R1650 MemRRow650 MemRCol650 10000.000000
R1687 MemRRow687 MemRCol687 10000.000000
R1725 MemRRow725 MemRCol725 10000.000000
R1764 MemRRow764 MemRCol764 10000.000000
R1804 MemRRow804 MemRCol804 10000.000000
R1845 MemRRow845 MemRCol845 10000.000000
R1887 MemRRow887 MemRCol887 10000.000000
R1930 MemRRow930 MemRCol930 10000.000000
R1974 MemRRow974 MemRCol974 10000.000000
R11019 MemRRow1019 MemRCol1019 10000.000000
R11065 MemRRow1065 MemRCol1065 10000.000000
R11112 MemRRow1112 MemRCol1112 10000.000000
R11160 MemRRow1160 MemRCol1160 10000.000000
R1154 MemRRow154 MemRCol154 10000.000000
R1173 MemRRow173 MemRCol173 10000.000000
R1193 MemRRow193 MemRCol193 10000.000000
R1214 MemRRow214 MemRCol214 10000.000000
R1236 MemRRow236 MemRCol236 10000.000000
R1259 MemRRow259 MemRCol259 10000.000000
R1283 MemRRow283 MemRCol283 10000.000000
R1308 MemRRow308 MemRCol308 10000.000000
R1334 MemRRow334 MemRCol334 10000.000000
R1361 MemRRow361 MemRCol361 10000.000000
R1389 MemRRow389 MemRCol389 10000.000000
R1418 MemRRow418 MemRCol418 10000.000000
R1448 MemRRow448 MemRCol448 10000.000000
R1479 MemRRow479 MemRCol479 10000.000000
R1511 MemRRow511 MemRCol511 10000.000000
R1544 MemRRow544 MemRCol544 10000.000000
R1578 MemRRow578 MemRCol578 10000.000000
R1613 MemRRow613 MemRCol613 10000.000000
R1649 MemRRow649 MemRCol649 10000.000000
R1686 MemRRow686 MemRCol686 10000.000000
R1724 MemRRow724 MemRCol724 10000.000000
R1763 MemRRow763 MemRCol763 10000.000000
R1803 MemRRow803 MemRCol803 10000.000000
R1844 MemRRow844 MemRCol844 10000.000000
R1886 MemRRow886 MemRCol886 10000.000000
R1929 MemRRow929 MemRCol929 10000.000000
R1973 MemRRow973 MemRCol973 10000.000000
R11018 MemRRow1018 MemRCol1018 10000.000000
R11064 MemRRow1064 MemRCol1064 10000.000000
R11111 MemRRow1111 MemRCol1111 10000.000000
R11159 MemRRow1159 MemRCol1159 10000.000000
R11208 MemRRow1208 MemRCol1208 10000.000000
R1172 MemRRow172 MemRCol172 10000.000000
R1192 MemRRow192 MemRCol192 10000.000000
R1213 MemRRow213 MemRCol213 10000.000000
R1235 MemRRow235 MemRCol235 10000.000000
R1258 MemRRow258 MemRCol258 10000.000000
R1282 MemRRow282 MemRCol282 10000.000000
R1307 MemRRow307 MemRCol307 10000.000000
R1333 MemRRow333 MemRCol333 10000.000000
R1360 MemRRow360 MemRCol360 10000.000000
R1388 MemRRow388 MemRCol388 10000.000000
R1417 MemRRow417 MemRCol417 10000.000000
R1447 MemRRow447 MemRCol447 10000.000000
R1478 MemRRow478 MemRCol478 10000.000000
R1510 MemRRow510 MemRCol510 10000.000000
R1543 MemRRow543 MemRCol543 10000.000000
R1577 MemRRow577 MemRCol577 10000.000000
R1612 MemRRow612 MemRCol612 10000.000000
R1648 MemRRow648 MemRCol648 10000.000000
R1685 MemRRow685 MemRCol685 10000.000000
R1723 MemRRow723 MemRCol723 10000.000000
R1762 MemRRow762 MemRCol762 10000.000000
R1802 MemRRow802 MemRCol802 10000.000000
R1843 MemRRow843 MemRCol843 10000.000000
R1885 MemRRow885 MemRCol885 10000.000000
R1928 MemRRow928 MemRCol928 10000.000000
R1972 MemRRow972 MemRCol972 10000.000000
R11017 MemRRow1017 MemRCol1017 10000.000000
R11063 MemRRow1063 MemRCol1063 10000.000000
R11110 MemRRow1110 MemRCol1110 10000.000000
R11158 MemRRow1158 MemRCol1158 10000.000000
R11207 MemRRow1207 MemRCol1207 10000.000000
R11257 MemRRow1257 MemRCol1257 10000.000000
R1191 MemRRow191 MemRCol191 10000.000000
R1212 MemRRow212 MemRCol212 10000.000000
R1234 MemRRow234 MemRCol234 10000.000000
R1257 MemRRow257 MemRCol257 10000.000000
R1281 MemRRow281 MemRCol281 10000.000000
R1306 MemRRow306 MemRCol306 10000.000000
R1332 MemRRow332 MemRCol332 10000.000000
R1359 MemRRow359 MemRCol359 10000.000000
R1387 MemRRow387 MemRCol387 10000.000000
R1416 MemRRow416 MemRCol416 10000.000000
R1446 MemRRow446 MemRCol446 10000.000000
R1477 MemRRow477 MemRCol477 10000.000000
R1509 MemRRow509 MemRCol509 10000.000000
R1542 MemRRow542 MemRCol542 10000.000000
R1576 MemRRow576 MemRCol576 10000.000000
R1611 MemRRow611 MemRCol611 10000.000000
R1647 MemRRow647 MemRCol647 10000.000000
R1684 MemRRow684 MemRCol684 10000.000000
R1722 MemRRow722 MemRCol722 10000.000000
R1761 MemRRow761 MemRCol761 10000.000000
R1801 MemRRow801 MemRCol801 10000.000000
R1842 MemRRow842 MemRCol842 10000.000000
R1884 MemRRow884 MemRCol884 10000.000000
R1927 MemRRow927 MemRCol927 10000.000000
R1971 MemRRow971 MemRCol971 10000.000000
R11016 MemRRow1016 MemRCol1016 10000.000000
R11062 MemRRow1062 MemRCol1062 10000.000000
R11109 MemRRow1109 MemRCol1109 10000.000000
R11157 MemRRow1157 MemRCol1157 10000.000000
R11206 MemRRow1206 MemRCol1206 10000.000000
R11256 MemRRow1256 MemRCol1256 10000.000000
R11307 MemRRow1307 MemRCol1307 10000.000000
R1211 MemRRow211 MemRCol211 10000.000000
R1233 MemRRow233 MemRCol233 10000.000000
R1256 MemRRow256 MemRCol256 10000.000000
R1280 MemRRow280 MemRCol280 10000.000000
R1305 MemRRow305 MemRCol305 10000.000000
R1331 MemRRow331 MemRCol331 10000.000000
R1358 MemRRow358 MemRCol358 10000.000000
R1386 MemRRow386 MemRCol386 10000.000000
R1415 MemRRow415 MemRCol415 10000.000000
R1445 MemRRow445 MemRCol445 10000.000000
R1476 MemRRow476 MemRCol476 10000.000000
R1508 MemRRow508 MemRCol508 10000.000000
R1541 MemRRow541 MemRCol541 10000.000000
R1575 MemRRow575 MemRCol575 10000.000000
R1610 MemRRow610 MemRCol610 10000.000000
R1646 MemRRow646 MemRCol646 10000.000000
R1683 MemRRow683 MemRCol683 10000.000000
R1721 MemRRow721 MemRCol721 10000.000000
R1760 MemRRow760 MemRCol760 10000.000000
R1800 MemRRow800 MemRCol800 10000.000000
R1841 MemRRow841 MemRCol841 10000.000000
R1883 MemRRow883 MemRCol883 10000.000000
R1926 MemRRow926 MemRCol926 10000.000000
R1970 MemRRow970 MemRCol970 10000.000000
R11015 MemRRow1015 MemRCol1015 10000.000000
R11061 MemRRow1061 MemRCol1061 10000.000000
R11108 MemRRow1108 MemRCol1108 10000.000000
R11156 MemRRow1156 MemRCol1156 10000.000000
R11205 MemRRow1205 MemRCol1205 10000.000000
R11255 MemRRow1255 MemRCol1255 10000.000000
R11306 MemRRow1306 MemRCol1306 10000.000000
R11358 MemRRow1358 MemRCol1358 10000.000000
R1232 MemRRow232 MemRCol232 10000.000000
R1255 MemRRow255 MemRCol255 10000.000000
R1279 MemRRow279 MemRCol279 10000.000000
R1304 MemRRow304 MemRCol304 10000.000000
R1330 MemRRow330 MemRCol330 10000.000000
R1357 MemRRow357 MemRCol357 10000.000000
R1385 MemRRow385 MemRCol385 10000.000000
R1414 MemRRow414 MemRCol414 10000.000000
R1444 MemRRow444 MemRCol444 10000.000000
R1475 MemRRow475 MemRCol475 10000.000000
R1507 MemRRow507 MemRCol507 10000.000000
R1540 MemRRow540 MemRCol540 10000.000000
R1574 MemRRow574 MemRCol574 10000.000000
R1609 MemRRow609 MemRCol609 10000.000000
R1645 MemRRow645 MemRCol645 10000.000000
R1682 MemRRow682 MemRCol682 10000.000000
R1720 MemRRow720 MemRCol720 10000.000000
R1759 MemRRow759 MemRCol759 10000.000000
R1799 MemRRow799 MemRCol799 10000.000000
R1840 MemRRow840 MemRCol840 10000.000000
R1882 MemRRow882 MemRCol882 10000.000000
R1925 MemRRow925 MemRCol925 10000.000000
R1969 MemRRow969 MemRCol969 10000.000000
R11014 MemRRow1014 MemRCol1014 10000.000000
R11060 MemRRow1060 MemRCol1060 10000.000000
R11107 MemRRow1107 MemRCol1107 10000.000000
R11155 MemRRow1155 MemRCol1155 10000.000000
R11204 MemRRow1204 MemRCol1204 10000.000000
R11254 MemRRow1254 MemRCol1254 10000.000000
R11305 MemRRow1305 MemRCol1305 10000.000000
R11357 MemRRow1357 MemRCol1357 10000.000000
R11410 MemRRow1410 MemRCol1410 10000.000000
R1254 MemRRow254 MemRCol254 10000.000000
R1278 MemRRow278 MemRCol278 10000.000000
R1303 MemRRow303 MemRCol303 10000.000000
R1329 MemRRow329 MemRCol329 10000.000000
R1356 MemRRow356 MemRCol356 10000.000000
R1384 MemRRow384 MemRCol384 10000.000000
R1413 MemRRow413 MemRCol413 10000.000000
R1443 MemRRow443 MemRCol443 10000.000000
R1474 MemRRow474 MemRCol474 10000.000000
R1506 MemRRow506 MemRCol506 10000.000000
R1539 MemRRow539 MemRCol539 10000.000000
R1573 MemRRow573 MemRCol573 10000.000000
R1608 MemRRow608 MemRCol608 10000.000000
R1644 MemRRow644 MemRCol644 10000.000000
R1681 MemRRow681 MemRCol681 10000.000000
R1719 MemRRow719 MemRCol719 10000.000000
R1758 MemRRow758 MemRCol758 10000.000000
R1798 MemRRow798 MemRCol798 10000.000000
R1839 MemRRow839 MemRCol839 10000.000000
R1881 MemRRow881 MemRCol881 10000.000000
R1924 MemRRow924 MemRCol924 10000.000000
R1968 MemRRow968 MemRCol968 10000.000000
R11013 MemRRow1013 MemRCol1013 10000.000000
R11059 MemRRow1059 MemRCol1059 10000.000000
R11106 MemRRow1106 MemRCol1106 10000.000000
R11154 MemRRow1154 MemRCol1154 10000.000000
R11203 MemRRow1203 MemRCol1203 10000.000000
R11253 MemRRow1253 MemRCol1253 10000.000000
R11304 MemRRow1304 MemRCol1304 10000.000000
R11356 MemRRow1356 MemRCol1356 10000.000000
R11409 MemRRow1409 MemRCol1409 10000.000000
R11463 MemRRow1463 MemRCol1463 10000.000000
R1277 MemRRow277 MemRCol277 10000.000000
R1302 MemRRow302 MemRCol302 10000.000000
R1328 MemRRow328 MemRCol328 10000.000000
R1355 MemRRow355 MemRCol355 10000.000000
R1383 MemRRow383 MemRCol383 10000.000000
R1412 MemRRow412 MemRCol412 10000.000000
R1442 MemRRow442 MemRCol442 10000.000000
R1473 MemRRow473 MemRCol473 10000.000000
R1505 MemRRow505 MemRCol505 10000.000000
R1538 MemRRow538 MemRCol538 10000.000000
R1572 MemRRow572 MemRCol572 10000.000000
R1607 MemRRow607 MemRCol607 10000.000000
R1643 MemRRow643 MemRCol643 10000.000000
R1680 MemRRow680 MemRCol680 10000.000000
R1718 MemRRow718 MemRCol718 10000.000000
R1757 MemRRow757 MemRCol757 10000.000000
R1797 MemRRow797 MemRCol797 10000.000000
R1838 MemRRow838 MemRCol838 10000.000000
R1880 MemRRow880 MemRCol880 10000.000000
R1923 MemRRow923 MemRCol923 10000.000000
R1967 MemRRow967 MemRCol967 10000.000000
R11012 MemRRow1012 MemRCol1012 10000.000000
R11058 MemRRow1058 MemRCol1058 10000.000000
R11105 MemRRow1105 MemRCol1105 10000.000000
R11153 MemRRow1153 MemRCol1153 10000.000000
R11202 MemRRow1202 MemRCol1202 10000.000000
R11252 MemRRow1252 MemRCol1252 10000.000000
R11303 MemRRow1303 MemRCol1303 10000.000000
R11355 MemRRow1355 MemRCol1355 10000.000000
R11408 MemRRow1408 MemRCol1408 10000.000000
R11462 MemRRow1462 MemRCol1462 10000.000000
R11517 MemRRow1517 MemRCol1517 10000.000000
R1301 MemRRow301 MemRCol301 10000.000000
R1327 MemRRow327 MemRCol327 10000.000000
R1354 MemRRow354 MemRCol354 10000.000000
R1382 MemRRow382 MemRCol382 10000.000000
R1411 MemRRow411 MemRCol411 10000.000000
R1441 MemRRow441 MemRCol441 10000.000000
R1472 MemRRow472 MemRCol472 10000.000000
R1504 MemRRow504 MemRCol504 10000.000000
R1537 MemRRow537 MemRCol537 10000.000000
R1571 MemRRow571 MemRCol571 10000.000000
R1606 MemRRow606 MemRCol606 10000.000000
R1642 MemRRow642 MemRCol642 10000.000000
R1679 MemRRow679 MemRCol679 10000.000000
R1717 MemRRow717 MemRCol717 10000.000000
R1756 MemRRow756 MemRCol756 10000.000000
R1796 MemRRow796 MemRCol796 10000.000000
R1837 MemRRow837 MemRCol837 10000.000000
R1879 MemRRow879 MemRCol879 10000.000000
R1922 MemRRow922 MemRCol922 10000.000000
R1966 MemRRow966 MemRCol966 10000.000000
R11011 MemRRow1011 MemRCol1011 10000.000000
R11057 MemRRow1057 MemRCol1057 10000.000000
R11104 MemRRow1104 MemRCol1104 10000.000000
R11152 MemRRow1152 MemRCol1152 10000.000000
R11201 MemRRow1201 MemRCol1201 10000.000000
R11251 MemRRow1251 MemRCol1251 10000.000000
R11302 MemRRow1302 MemRCol1302 10000.000000
R11354 MemRRow1354 MemRCol1354 10000.000000
R11407 MemRRow1407 MemRCol1407 10000.000000
R11461 MemRRow1461 MemRCol1461 10000.000000
R11516 MemRRow1516 MemRCol1516 10000.000000
R11572 MemRRow1572 MemRCol1572 10000.000000
R1326 MemRRow326 MemRCol326 10000.000000
R1353 MemRRow353 MemRCol353 10000.000000
R1381 MemRRow381 MemRCol381 10000.000000
R1410 MemRRow410 MemRCol410 10000.000000
R1440 MemRRow440 MemRCol440 10000.000000
R1471 MemRRow471 MemRCol471 10000.000000
R1503 MemRRow503 MemRCol503 10000.000000
R1536 MemRRow536 MemRCol536 10000.000000
R1570 MemRRow570 MemRCol570 10000.000000
R1605 MemRRow605 MemRCol605 10000.000000
R1641 MemRRow641 MemRCol641 10000.000000
R1678 MemRRow678 MemRCol678 10000.000000
R1716 MemRRow716 MemRCol716 10000.000000
R1755 MemRRow755 MemRCol755 10000.000000
R1795 MemRRow795 MemRCol795 10000.000000
R1836 MemRRow836 MemRCol836 10000.000000
R1878 MemRRow878 MemRCol878 10000.000000
R1921 MemRRow921 MemRCol921 10000.000000
R1965 MemRRow965 MemRCol965 10000.000000
R11010 MemRRow1010 MemRCol1010 10000.000000
R11056 MemRRow1056 MemRCol1056 10000.000000
R11103 MemRRow1103 MemRCol1103 10000.000000
R11151 MemRRow1151 MemRCol1151 10000.000000
R11200 MemRRow1200 MemRCol1200 10000.000000
R11250 MemRRow1250 MemRCol1250 10000.000000
R11301 MemRRow1301 MemRCol1301 10000.000000
R11353 MemRRow1353 MemRCol1353 10000.000000
R11406 MemRRow1406 MemRCol1406 10000.000000
R11460 MemRRow1460 MemRCol1460 10000.000000
R11515 MemRRow1515 MemRCol1515 10000.000000
R11571 MemRRow1571 MemRCol1571 10000.000000
R11628 MemRRow1628 MemRCol1628 10000.000000
R1352 MemRRow352 MemRCol352 10000.000000
R1380 MemRRow380 MemRCol380 10000.000000
R1409 MemRRow409 MemRCol409 10000.000000
R1439 MemRRow439 MemRCol439 10000.000000
R1470 MemRRow470 MemRCol470 10000.000000
R1502 MemRRow502 MemRCol502 10000.000000
R1535 MemRRow535 MemRCol535 10000.000000
R1569 MemRRow569 MemRCol569 10000.000000
R1604 MemRRow604 MemRCol604 10000.000000
R1640 MemRRow640 MemRCol640 10000.000000
R1677 MemRRow677 MemRCol677 10000.000000
R1715 MemRRow715 MemRCol715 10000.000000
R1754 MemRRow754 MemRCol754 10000.000000
R1794 MemRRow794 MemRCol794 10000.000000
R1835 MemRRow835 MemRCol835 10000.000000
R1877 MemRRow877 MemRCol877 10000.000000
R1920 MemRRow920 MemRCol920 10000.000000
R1964 MemRRow964 MemRCol964 10000.000000
R11009 MemRRow1009 MemRCol1009 10000.000000
R11055 MemRRow1055 MemRCol1055 10000.000000
R11102 MemRRow1102 MemRCol1102 10000.000000
R11150 MemRRow1150 MemRCol1150 10000.000000
R11199 MemRRow1199 MemRCol1199 10000.000000
R11249 MemRRow1249 MemRCol1249 10000.000000
R11300 MemRRow1300 MemRCol1300 10000.000000
R11352 MemRRow1352 MemRCol1352 10000.000000
R11405 MemRRow1405 MemRCol1405 10000.000000
R11459 MemRRow1459 MemRCol1459 10000.000000
R11514 MemRRow1514 MemRCol1514 10000.000000
R11570 MemRRow1570 MemRCol1570 10000.000000
R11627 MemRRow1627 MemRCol1627 10000.000000
R11685 MemRRow1685 MemRCol1685 10000.000000
R1379 MemRRow379 MemRCol379 10000.000000
R1408 MemRRow408 MemRCol408 10000.000000
R1438 MemRRow438 MemRCol438 10000.000000
R1469 MemRRow469 MemRCol469 10000.000000
R1501 MemRRow501 MemRCol501 10000.000000
R1534 MemRRow534 MemRCol534 10000.000000
R1568 MemRRow568 MemRCol568 10000.000000
R1603 MemRRow603 MemRCol603 10000.000000
R1639 MemRRow639 MemRCol639 10000.000000
R1676 MemRRow676 MemRCol676 10000.000000
R1714 MemRRow714 MemRCol714 10000.000000
R1753 MemRRow753 MemRCol753 10000.000000
R1793 MemRRow793 MemRCol793 10000.000000
R1834 MemRRow834 MemRCol834 10000.000000
R1876 MemRRow876 MemRCol876 10000.000000
R1919 MemRRow919 MemRCol919 10000.000000
R1963 MemRRow963 MemRCol963 10000.000000
R11008 MemRRow1008 MemRCol1008 10000.000000
R11054 MemRRow1054 MemRCol1054 10000.000000
R11101 MemRRow1101 MemRCol1101 10000.000000
R11149 MemRRow1149 MemRCol1149 10000.000000
R11198 MemRRow1198 MemRCol1198 10000.000000
R11248 MemRRow1248 MemRCol1248 10000.000000
R11299 MemRRow1299 MemRCol1299 10000.000000
R11351 MemRRow1351 MemRCol1351 10000.000000
R11404 MemRRow1404 MemRCol1404 10000.000000
R11458 MemRRow1458 MemRCol1458 10000.000000
R11513 MemRRow1513 MemRCol1513 10000.000000
R11569 MemRRow1569 MemRCol1569 10000.000000
R11626 MemRRow1626 MemRCol1626 10000.000000
R11684 MemRRow1684 MemRCol1684 10000.000000
R11743 MemRRow1743 MemRCol1743 10000.000000
R1407 MemRRow407 MemRCol407 10000.000000
R1437 MemRRow437 MemRCol437 10000.000000
R1468 MemRRow468 MemRCol468 10000.000000
R1500 MemRRow500 MemRCol500 10000.000000
R1533 MemRRow533 MemRCol533 10000.000000
R1567 MemRRow567 MemRCol567 10000.000000
R1602 MemRRow602 MemRCol602 10000.000000
R1638 MemRRow638 MemRCol638 10000.000000
R1675 MemRRow675 MemRCol675 10000.000000
R1713 MemRRow713 MemRCol713 10000.000000
R1752 MemRRow752 MemRCol752 10000.000000
R1792 MemRRow792 MemRCol792 10000.000000
R1833 MemRRow833 MemRCol833 10000.000000
R1875 MemRRow875 MemRCol875 10000.000000
R1918 MemRRow918 MemRCol918 10000.000000
R1962 MemRRow962 MemRCol962 10000.000000
R11007 MemRRow1007 MemRCol1007 10000.000000
R11053 MemRRow1053 MemRCol1053 10000.000000
R11100 MemRRow1100 MemRCol1100 10000.000000
R11148 MemRRow1148 MemRCol1148 10000.000000
R11197 MemRRow1197 MemRCol1197 10000.000000
R11247 MemRRow1247 MemRCol1247 10000.000000
R11298 MemRRow1298 MemRCol1298 10000.000000
R11350 MemRRow1350 MemRCol1350 10000.000000
R11403 MemRRow1403 MemRCol1403 10000.000000
R11457 MemRRow1457 MemRCol1457 10000.000000
R11512 MemRRow1512 MemRCol1512 10000.000000
R11568 MemRRow1568 MemRCol1568 10000.000000
R11625 MemRRow1625 MemRCol1625 10000.000000
R11683 MemRRow1683 MemRCol1683 10000.000000
R11742 MemRRow1742 MemRCol1742 10000.000000
R11802 MemRRow1802 MemRCol1802 10000.000000
R1436 MemRRow436 MemRCol436 10000.000000
R1467 MemRRow467 MemRCol467 10000.000000
R1499 MemRRow499 MemRCol499 10000.000000
R1532 MemRRow532 MemRCol532 10000.000000
R1566 MemRRow566 MemRCol566 10000.000000
R1601 MemRRow601 MemRCol601 10000.000000
R1637 MemRRow637 MemRCol637 10000.000000
R1674 MemRRow674 MemRCol674 10000.000000
R1712 MemRRow712 MemRCol712 10000.000000
R1751 MemRRow751 MemRCol751 10000.000000
R1791 MemRRow791 MemRCol791 10000.000000
R1832 MemRRow832 MemRCol832 10000.000000
R1874 MemRRow874 MemRCol874 10000.000000
R1917 MemRRow917 MemRCol917 10000.000000
R1961 MemRRow961 MemRCol961 10000.000000
R11006 MemRRow1006 MemRCol1006 10000.000000
R11052 MemRRow1052 MemRCol1052 10000.000000
R11099 MemRRow1099 MemRCol1099 10000.000000
R11147 MemRRow1147 MemRCol1147 10000.000000
R11196 MemRRow1196 MemRCol1196 10000.000000
R11246 MemRRow1246 MemRCol1246 10000.000000
R11297 MemRRow1297 MemRCol1297 10000.000000
R11349 MemRRow1349 MemRCol1349 10000.000000
R11402 MemRRow1402 MemRCol1402 10000.000000
R11456 MemRRow1456 MemRCol1456 10000.000000
R11511 MemRRow1511 MemRCol1511 10000.000000
R11567 MemRRow1567 MemRCol1567 10000.000000
R11624 MemRRow1624 MemRCol1624 10000.000000
R11682 MemRRow1682 MemRCol1682 10000.000000
R11741 MemRRow1741 MemRCol1741 10000.000000
R11801 MemRRow1801 MemRCol1801 10000.000000
R11862 MemRRow1862 MemRCol1862 10000.000000
R1466 MemRRow466 MemRCol466 10000.000000
R1498 MemRRow498 MemRCol498 10000.000000
R1531 MemRRow531 MemRCol531 10000.000000
R1565 MemRRow565 MemRCol565 10000.000000
R1600 MemRRow600 MemRCol600 10000.000000
R1636 MemRRow636 MemRCol636 10000.000000
R1673 MemRRow673 MemRCol673 10000.000000
R1711 MemRRow711 MemRCol711 10000.000000
R1750 MemRRow750 MemRCol750 10000.000000
R1790 MemRRow790 MemRCol790 10000.000000
R1831 MemRRow831 MemRCol831 10000.000000
R1873 MemRRow873 MemRCol873 10000.000000
R1916 MemRRow916 MemRCol916 10000.000000
R1960 MemRRow960 MemRCol960 10000.000000
R11005 MemRRow1005 MemRCol1005 10000.000000
R11051 MemRRow1051 MemRCol1051 10000.000000
R11098 MemRRow1098 MemRCol1098 10000.000000
R11146 MemRRow1146 MemRCol1146 10000.000000
R11195 MemRRow1195 MemRCol1195 10000.000000
R11245 MemRRow1245 MemRCol1245 10000.000000
R11296 MemRRow1296 MemRCol1296 10000.000000
R11348 MemRRow1348 MemRCol1348 10000.000000
R11401 MemRRow1401 MemRCol1401 10000.000000
R11455 MemRRow1455 MemRCol1455 10000.000000
R11510 MemRRow1510 MemRCol1510 10000.000000
R11566 MemRRow1566 MemRCol1566 10000.000000
R11623 MemRRow1623 MemRCol1623 10000.000000
R11681 MemRRow1681 MemRCol1681 10000.000000
R11740 MemRRow1740 MemRCol1740 10000.000000
R11800 MemRRow1800 MemRCol1800 10000.000000
R11861 MemRRow1861 MemRCol1861 10000.000000
R11923 MemRRow1923 MemRCol1923 10000.000000
R1497 MemRRow497 MemRCol497 10000.000000
R1530 MemRRow530 MemRCol530 10000.000000
R1564 MemRRow564 MemRCol564 10000.000000
R1599 MemRRow599 MemRCol599 10000.000000
R1635 MemRRow635 MemRCol635 10000.000000
R1672 MemRRow672 MemRCol672 10000.000000
R1710 MemRRow710 MemRCol710 10000.000000
R1749 MemRRow749 MemRCol749 10000.000000
R1789 MemRRow789 MemRCol789 10000.000000
R1830 MemRRow830 MemRCol830 10000.000000
R1872 MemRRow872 MemRCol872 10000.000000
R1915 MemRRow915 MemRCol915 10000.000000
R1959 MemRRow959 MemRCol959 10000.000000
R11004 MemRRow1004 MemRCol1004 10000.000000
R11050 MemRRow1050 MemRCol1050 10000.000000
R11097 MemRRow1097 MemRCol1097 10000.000000
R11145 MemRRow1145 MemRCol1145 10000.000000
R11194 MemRRow1194 MemRCol1194 10000.000000
R11244 MemRRow1244 MemRCol1244 10000.000000
R11295 MemRRow1295 MemRCol1295 10000.000000
R11347 MemRRow1347 MemRCol1347 10000.000000
R11400 MemRRow1400 MemRCol1400 10000.000000
R11454 MemRRow1454 MemRCol1454 10000.000000
R11509 MemRRow1509 MemRCol1509 10000.000000
R11565 MemRRow1565 MemRCol1565 10000.000000
R11622 MemRRow1622 MemRCol1622 10000.000000
R11680 MemRRow1680 MemRCol1680 10000.000000
R11739 MemRRow1739 MemRCol1739 10000.000000
R11799 MemRRow1799 MemRCol1799 10000.000000
R11860 MemRRow1860 MemRCol1860 10000.000000
R11922 MemRRow1922 MemRCol1922 10000.000000
R11985 MemRRow1985 MemRCol1985 10000.000000
R1529 MemRRow529 MemRCol529 10000.000000
R1563 MemRRow563 MemRCol563 10000.000000
R1598 MemRRow598 MemRCol598 10000.000000
R1634 MemRRow634 MemRCol634 10000.000000
R1671 MemRRow671 MemRCol671 10000.000000
R1709 MemRRow709 MemRCol709 10000.000000
R1748 MemRRow748 MemRCol748 10000.000000
R1788 MemRRow788 MemRCol788 10000.000000
R1829 MemRRow829 MemRCol829 10000.000000
R1871 MemRRow871 MemRCol871 10000.000000
R1914 MemRRow914 MemRCol914 10000.000000
R1958 MemRRow958 MemRCol958 10000.000000
R11003 MemRRow1003 MemRCol1003 10000.000000
R11049 MemRRow1049 MemRCol1049 10000.000000
R11096 MemRRow1096 MemRCol1096 10000.000000
R11144 MemRRow1144 MemRCol1144 10000.000000
R11193 MemRRow1193 MemRCol1193 10000.000000
R11243 MemRRow1243 MemRCol1243 10000.000000
R11294 MemRRow1294 MemRCol1294 10000.000000
R11346 MemRRow1346 MemRCol1346 10000.000000
R11399 MemRRow1399 MemRCol1399 10000.000000
R11453 MemRRow1453 MemRCol1453 10000.000000
R11508 MemRRow1508 MemRCol1508 10000.000000
R11564 MemRRow1564 MemRCol1564 10000.000000
R11621 MemRRow1621 MemRCol1621 10000.000000
R11679 MemRRow1679 MemRCol1679 10000.000000
R11738 MemRRow1738 MemRCol1738 10000.000000
R11798 MemRRow1798 MemRCol1798 10000.000000
R11859 MemRRow1859 MemRCol1859 10000.000000
R11921 MemRRow1921 MemRCol1921 10000.000000
R11984 MemRRow1984 MemRCol1984 10000.000000
R12048 MemRRow2048 MemRCol2048 10000.000000
R1562 MemRRow562 MemRCol562 10000.000000
R1597 MemRRow597 MemRCol597 10000.000000
R1633 MemRRow633 MemRCol633 10000.000000
R1670 MemRRow670 MemRCol670 10000.000000
R1708 MemRRow708 MemRCol708 10000.000000
R1747 MemRRow747 MemRCol747 10000.000000
R1787 MemRRow787 MemRCol787 10000.000000
R1828 MemRRow828 MemRCol828 10000.000000
R1870 MemRRow870 MemRCol870 10000.000000
R1913 MemRRow913 MemRCol913 10000.000000
R1957 MemRRow957 MemRCol957 10000.000000
R11002 MemRRow1002 MemRCol1002 10000.000000
R11048 MemRRow1048 MemRCol1048 10000.000000
R11095 MemRRow1095 MemRCol1095 10000.000000
R11143 MemRRow1143 MemRCol1143 10000.000000
R11192 MemRRow1192 MemRCol1192 10000.000000
R11242 MemRRow1242 MemRCol1242 10000.000000
R11293 MemRRow1293 MemRCol1293 10000.000000
R11345 MemRRow1345 MemRCol1345 10000.000000
R11398 MemRRow1398 MemRCol1398 10000.000000
R11452 MemRRow1452 MemRCol1452 10000.000000
R11507 MemRRow1507 MemRCol1507 10000.000000
R11563 MemRRow1563 MemRCol1563 10000.000000
R11620 MemRRow1620 MemRCol1620 10000.000000
R11678 MemRRow1678 MemRCol1678 10000.000000
R11737 MemRRow1737 MemRCol1737 10000.000000
R11797 MemRRow1797 MemRCol1797 10000.000000
R11858 MemRRow1858 MemRCol1858 10000.000000
R11920 MemRRow1920 MemRCol1920 10000.000000
R11983 MemRRow1983 MemRCol1983 10000.000000
R12047 MemRRow2047 MemRCol2047 10000.000000
R12112 MemRRow2112 MemRCol2112 10000.000000

*Line Row Resistances
R24 MemRRow4 MemRRow8 1000.000000
R28 MemRRow8 MemRRow13 1000.000000
R213 MemRRow13 MemRRow19 1000.000000
R219 MemRRow19 MemRRow26 1000.000000
R226 MemRRow26 MemRRow34 1000.000000
R234 MemRRow34 MemRRow43 1000.000000
R243 MemRRow43 MemRRow53 1000.000000
R253 MemRRow53 MemRRow64 1000.000000
R264 MemRRow64 MemRRow76 1000.000000
R276 MemRRow76 MemRRow89 1000.000000
R289 MemRRow89 MemRRow103 1000.000000
R2103 MemRRow103 MemRRow118 1000.000000
R2118 MemRRow118 MemRRow134 1000.000000
R2134 MemRRow134 MemRRow151 1000.000000
R2151 MemRRow151 MemRRow169 1000.000000
R2169 MemRRow169 MemRRow188 1000.000000
R2188 MemRRow188 MemRRow208 1000.000000
R2208 MemRRow208 MemRRow229 1000.000000
R2229 MemRRow229 MemRRow251 1000.000000
R2251 MemRRow251 MemRRow274 1000.000000
R2274 MemRRow274 MemRRow298 1000.000000
R2298 MemRRow298 MemRRow323 1000.000000
R2323 MemRRow323 MemRRow349 1000.000000
R2349 MemRRow349 MemRRow376 1000.000000
R2376 MemRRow376 MemRRow404 1000.000000
R2404 MemRRow404 MemRRow433 1000.000000
R2433 MemRRow433 MemRRow463 1000.000000
R2463 MemRRow463 MemRRow494 1000.000000
R2494 MemRRow494 MemRRow526 1000.000000
R2526 MemRRow526 MemRRow559 1000.000000
R2559 MemRRow559 MemRRow593 1000.000000
R2593 MemRRow593 MemRRow628 1000.000000
R27 MemRRow7 MemRRow12 1000.000000
R212 MemRRow12 MemRRow18 1000.000000
R218 MemRRow18 MemRRow25 1000.000000
R225 MemRRow25 MemRRow33 1000.000000
R233 MemRRow33 MemRRow42 1000.000000
R242 MemRRow42 MemRRow52 1000.000000
R252 MemRRow52 MemRRow63 1000.000000
R263 MemRRow63 MemRRow75 1000.000000
R275 MemRRow75 MemRRow88 1000.000000
R288 MemRRow88 MemRRow102 1000.000000
R2102 MemRRow102 MemRRow117 1000.000000
R2117 MemRRow117 MemRRow133 1000.000000
R2133 MemRRow133 MemRRow150 1000.000000
R2150 MemRRow150 MemRRow168 1000.000000
R2168 MemRRow168 MemRRow187 1000.000000
R2187 MemRRow187 MemRRow207 1000.000000
R2207 MemRRow207 MemRRow228 1000.000000
R2228 MemRRow228 MemRRow250 1000.000000
R2250 MemRRow250 MemRRow273 1000.000000
R2273 MemRRow273 MemRRow297 1000.000000
R2297 MemRRow297 MemRRow322 1000.000000
R2322 MemRRow322 MemRRow348 1000.000000
R2348 MemRRow348 MemRRow375 1000.000000
R2375 MemRRow375 MemRRow403 1000.000000
R2403 MemRRow403 MemRRow432 1000.000000
R2432 MemRRow432 MemRRow462 1000.000000
R2462 MemRRow462 MemRRow493 1000.000000
R2493 MemRRow493 MemRRow525 1000.000000
R2525 MemRRow525 MemRRow558 1000.000000
R2558 MemRRow558 MemRRow592 1000.000000
R2592 MemRRow592 MemRRow627 1000.000000
R2627 MemRRow627 MemRRow663 1000.000000
R211 MemRRow11 MemRRow17 1000.000000
R217 MemRRow17 MemRRow24 1000.000000
R224 MemRRow24 MemRRow32 1000.000000
R232 MemRRow32 MemRRow41 1000.000000
R241 MemRRow41 MemRRow51 1000.000000
R251 MemRRow51 MemRRow62 1000.000000
R262 MemRRow62 MemRRow74 1000.000000
R274 MemRRow74 MemRRow87 1000.000000
R287 MemRRow87 MemRRow101 1000.000000
R2101 MemRRow101 MemRRow116 1000.000000
R2116 MemRRow116 MemRRow132 1000.000000
R2132 MemRRow132 MemRRow149 1000.000000
R2149 MemRRow149 MemRRow167 1000.000000
R2167 MemRRow167 MemRRow186 1000.000000
R2186 MemRRow186 MemRRow206 1000.000000
R2206 MemRRow206 MemRRow227 1000.000000
R2227 MemRRow227 MemRRow249 1000.000000
R2249 MemRRow249 MemRRow272 1000.000000
R2272 MemRRow272 MemRRow296 1000.000000
R2296 MemRRow296 MemRRow321 1000.000000
R2321 MemRRow321 MemRRow347 1000.000000
R2347 MemRRow347 MemRRow374 1000.000000
R2374 MemRRow374 MemRRow402 1000.000000
R2402 MemRRow402 MemRRow431 1000.000000
R2431 MemRRow431 MemRRow461 1000.000000
R2461 MemRRow461 MemRRow492 1000.000000
R2492 MemRRow492 MemRRow524 1000.000000
R2524 MemRRow524 MemRRow557 1000.000000
R2557 MemRRow557 MemRRow591 1000.000000
R2591 MemRRow591 MemRRow626 1000.000000
R2626 MemRRow626 MemRRow662 1000.000000
R2662 MemRRow662 MemRRow699 1000.000000
R216 MemRRow16 MemRRow23 1000.000000
R223 MemRRow23 MemRRow31 1000.000000
R231 MemRRow31 MemRRow40 1000.000000
R240 MemRRow40 MemRRow50 1000.000000
R250 MemRRow50 MemRRow61 1000.000000
R261 MemRRow61 MemRRow73 1000.000000
R273 MemRRow73 MemRRow86 1000.000000
R286 MemRRow86 MemRRow100 1000.000000
R2100 MemRRow100 MemRRow115 1000.000000
R2115 MemRRow115 MemRRow131 1000.000000
R2131 MemRRow131 MemRRow148 1000.000000
R2148 MemRRow148 MemRRow166 1000.000000
R2166 MemRRow166 MemRRow185 1000.000000
R2185 MemRRow185 MemRRow205 1000.000000
R2205 MemRRow205 MemRRow226 1000.000000
R2226 MemRRow226 MemRRow248 1000.000000
R2248 MemRRow248 MemRRow271 1000.000000
R2271 MemRRow271 MemRRow295 1000.000000
R2295 MemRRow295 MemRRow320 1000.000000
R2320 MemRRow320 MemRRow346 1000.000000
R2346 MemRRow346 MemRRow373 1000.000000
R2373 MemRRow373 MemRRow401 1000.000000
R2401 MemRRow401 MemRRow430 1000.000000
R2430 MemRRow430 MemRRow460 1000.000000
R2460 MemRRow460 MemRRow491 1000.000000
R2491 MemRRow491 MemRRow523 1000.000000
R2523 MemRRow523 MemRRow556 1000.000000
R2556 MemRRow556 MemRRow590 1000.000000
R2590 MemRRow590 MemRRow625 1000.000000
R2625 MemRRow625 MemRRow661 1000.000000
R2661 MemRRow661 MemRRow698 1000.000000
R2698 MemRRow698 MemRRow736 1000.000000
R222 MemRRow22 MemRRow30 1000.000000
R230 MemRRow30 MemRRow39 1000.000000
R239 MemRRow39 MemRRow49 1000.000000
R249 MemRRow49 MemRRow60 1000.000000
R260 MemRRow60 MemRRow72 1000.000000
R272 MemRRow72 MemRRow85 1000.000000
R285 MemRRow85 MemRRow99 1000.000000
R299 MemRRow99 MemRRow114 1000.000000
R2114 MemRRow114 MemRRow130 1000.000000
R2130 MemRRow130 MemRRow147 1000.000000
R2147 MemRRow147 MemRRow165 1000.000000
R2165 MemRRow165 MemRRow184 1000.000000
R2184 MemRRow184 MemRRow204 1000.000000
R2204 MemRRow204 MemRRow225 1000.000000
R2225 MemRRow225 MemRRow247 1000.000000
R2247 MemRRow247 MemRRow270 1000.000000
R2270 MemRRow270 MemRRow294 1000.000000
R2294 MemRRow294 MemRRow319 1000.000000
R2319 MemRRow319 MemRRow345 1000.000000
R2345 MemRRow345 MemRRow372 1000.000000
R2372 MemRRow372 MemRRow400 1000.000000
R2400 MemRRow400 MemRRow429 1000.000000
R2429 MemRRow429 MemRRow459 1000.000000
R2459 MemRRow459 MemRRow490 1000.000000
R2490 MemRRow490 MemRRow522 1000.000000
R2522 MemRRow522 MemRRow555 1000.000000
R2555 MemRRow555 MemRRow589 1000.000000
R2589 MemRRow589 MemRRow624 1000.000000
R2624 MemRRow624 MemRRow660 1000.000000
R2660 MemRRow660 MemRRow697 1000.000000
R2697 MemRRow697 MemRRow735 1000.000000
R2735 MemRRow735 MemRRow774 1000.000000
R229 MemRRow29 MemRRow38 1000.000000
R238 MemRRow38 MemRRow48 1000.000000
R248 MemRRow48 MemRRow59 1000.000000
R259 MemRRow59 MemRRow71 1000.000000
R271 MemRRow71 MemRRow84 1000.000000
R284 MemRRow84 MemRRow98 1000.000000
R298 MemRRow98 MemRRow113 1000.000000
R2113 MemRRow113 MemRRow129 1000.000000
R2129 MemRRow129 MemRRow146 1000.000000
R2146 MemRRow146 MemRRow164 1000.000000
R2164 MemRRow164 MemRRow183 1000.000000
R2183 MemRRow183 MemRRow203 1000.000000
R2203 MemRRow203 MemRRow224 1000.000000
R2224 MemRRow224 MemRRow246 1000.000000
R2246 MemRRow246 MemRRow269 1000.000000
R2269 MemRRow269 MemRRow293 1000.000000
R2293 MemRRow293 MemRRow318 1000.000000
R2318 MemRRow318 MemRRow344 1000.000000
R2344 MemRRow344 MemRRow371 1000.000000
R2371 MemRRow371 MemRRow399 1000.000000
R2399 MemRRow399 MemRRow428 1000.000000
R2428 MemRRow428 MemRRow458 1000.000000
R2458 MemRRow458 MemRRow489 1000.000000
R2489 MemRRow489 MemRRow521 1000.000000
R2521 MemRRow521 MemRRow554 1000.000000
R2554 MemRRow554 MemRRow588 1000.000000
R2588 MemRRow588 MemRRow623 1000.000000
R2623 MemRRow623 MemRRow659 1000.000000
R2659 MemRRow659 MemRRow696 1000.000000
R2696 MemRRow696 MemRRow734 1000.000000
R2734 MemRRow734 MemRRow773 1000.000000
R2773 MemRRow773 MemRRow813 1000.000000
R237 MemRRow37 MemRRow47 1000.000000
R247 MemRRow47 MemRRow58 1000.000000
R258 MemRRow58 MemRRow70 1000.000000
R270 MemRRow70 MemRRow83 1000.000000
R283 MemRRow83 MemRRow97 1000.000000
R297 MemRRow97 MemRRow112 1000.000000
R2112 MemRRow112 MemRRow128 1000.000000
R2128 MemRRow128 MemRRow145 1000.000000
R2145 MemRRow145 MemRRow163 1000.000000
R2163 MemRRow163 MemRRow182 1000.000000
R2182 MemRRow182 MemRRow202 1000.000000
R2202 MemRRow202 MemRRow223 1000.000000
R2223 MemRRow223 MemRRow245 1000.000000
R2245 MemRRow245 MemRRow268 1000.000000
R2268 MemRRow268 MemRRow292 1000.000000
R2292 MemRRow292 MemRRow317 1000.000000
R2317 MemRRow317 MemRRow343 1000.000000
R2343 MemRRow343 MemRRow370 1000.000000
R2370 MemRRow370 MemRRow398 1000.000000
R2398 MemRRow398 MemRRow427 1000.000000
R2427 MemRRow427 MemRRow457 1000.000000
R2457 MemRRow457 MemRRow488 1000.000000
R2488 MemRRow488 MemRRow520 1000.000000
R2520 MemRRow520 MemRRow553 1000.000000
R2553 MemRRow553 MemRRow587 1000.000000
R2587 MemRRow587 MemRRow622 1000.000000
R2622 MemRRow622 MemRRow658 1000.000000
R2658 MemRRow658 MemRRow695 1000.000000
R2695 MemRRow695 MemRRow733 1000.000000
R2733 MemRRow733 MemRRow772 1000.000000
R2772 MemRRow772 MemRRow812 1000.000000
R2812 MemRRow812 MemRRow853 1000.000000
R246 MemRRow46 MemRRow57 1000.000000
R257 MemRRow57 MemRRow69 1000.000000
R269 MemRRow69 MemRRow82 1000.000000
R282 MemRRow82 MemRRow96 1000.000000
R296 MemRRow96 MemRRow111 1000.000000
R2111 MemRRow111 MemRRow127 1000.000000
R2127 MemRRow127 MemRRow144 1000.000000
R2144 MemRRow144 MemRRow162 1000.000000
R2162 MemRRow162 MemRRow181 1000.000000
R2181 MemRRow181 MemRRow201 1000.000000
R2201 MemRRow201 MemRRow222 1000.000000
R2222 MemRRow222 MemRRow244 1000.000000
R2244 MemRRow244 MemRRow267 1000.000000
R2267 MemRRow267 MemRRow291 1000.000000
R2291 MemRRow291 MemRRow316 1000.000000
R2316 MemRRow316 MemRRow342 1000.000000
R2342 MemRRow342 MemRRow369 1000.000000
R2369 MemRRow369 MemRRow397 1000.000000
R2397 MemRRow397 MemRRow426 1000.000000
R2426 MemRRow426 MemRRow456 1000.000000
R2456 MemRRow456 MemRRow487 1000.000000
R2487 MemRRow487 MemRRow519 1000.000000
R2519 MemRRow519 MemRRow552 1000.000000
R2552 MemRRow552 MemRRow586 1000.000000
R2586 MemRRow586 MemRRow621 1000.000000
R2621 MemRRow621 MemRRow657 1000.000000
R2657 MemRRow657 MemRRow694 1000.000000
R2694 MemRRow694 MemRRow732 1000.000000
R2732 MemRRow732 MemRRow771 1000.000000
R2771 MemRRow771 MemRRow811 1000.000000
R2811 MemRRow811 MemRRow852 1000.000000
R2852 MemRRow852 MemRRow894 1000.000000
R256 MemRRow56 MemRRow68 1000.000000
R268 MemRRow68 MemRRow81 1000.000000
R281 MemRRow81 MemRRow95 1000.000000
R295 MemRRow95 MemRRow110 1000.000000
R2110 MemRRow110 MemRRow126 1000.000000
R2126 MemRRow126 MemRRow143 1000.000000
R2143 MemRRow143 MemRRow161 1000.000000
R2161 MemRRow161 MemRRow180 1000.000000
R2180 MemRRow180 MemRRow200 1000.000000
R2200 MemRRow200 MemRRow221 1000.000000
R2221 MemRRow221 MemRRow243 1000.000000
R2243 MemRRow243 MemRRow266 1000.000000
R2266 MemRRow266 MemRRow290 1000.000000
R2290 MemRRow290 MemRRow315 1000.000000
R2315 MemRRow315 MemRRow341 1000.000000
R2341 MemRRow341 MemRRow368 1000.000000
R2368 MemRRow368 MemRRow396 1000.000000
R2396 MemRRow396 MemRRow425 1000.000000
R2425 MemRRow425 MemRRow455 1000.000000
R2455 MemRRow455 MemRRow486 1000.000000
R2486 MemRRow486 MemRRow518 1000.000000
R2518 MemRRow518 MemRRow551 1000.000000
R2551 MemRRow551 MemRRow585 1000.000000
R2585 MemRRow585 MemRRow620 1000.000000
R2620 MemRRow620 MemRRow656 1000.000000
R2656 MemRRow656 MemRRow693 1000.000000
R2693 MemRRow693 MemRRow731 1000.000000
R2731 MemRRow731 MemRRow770 1000.000000
R2770 MemRRow770 MemRRow810 1000.000000
R2810 MemRRow810 MemRRow851 1000.000000
R2851 MemRRow851 MemRRow893 1000.000000
R2893 MemRRow893 MemRRow936 1000.000000
R267 MemRRow67 MemRRow80 1000.000000
R280 MemRRow80 MemRRow94 1000.000000
R294 MemRRow94 MemRRow109 1000.000000
R2109 MemRRow109 MemRRow125 1000.000000
R2125 MemRRow125 MemRRow142 1000.000000
R2142 MemRRow142 MemRRow160 1000.000000
R2160 MemRRow160 MemRRow179 1000.000000
R2179 MemRRow179 MemRRow199 1000.000000
R2199 MemRRow199 MemRRow220 1000.000000
R2220 MemRRow220 MemRRow242 1000.000000
R2242 MemRRow242 MemRRow265 1000.000000
R2265 MemRRow265 MemRRow289 1000.000000
R2289 MemRRow289 MemRRow314 1000.000000
R2314 MemRRow314 MemRRow340 1000.000000
R2340 MemRRow340 MemRRow367 1000.000000
R2367 MemRRow367 MemRRow395 1000.000000
R2395 MemRRow395 MemRRow424 1000.000000
R2424 MemRRow424 MemRRow454 1000.000000
R2454 MemRRow454 MemRRow485 1000.000000
R2485 MemRRow485 MemRRow517 1000.000000
R2517 MemRRow517 MemRRow550 1000.000000
R2550 MemRRow550 MemRRow584 1000.000000
R2584 MemRRow584 MemRRow619 1000.000000
R2619 MemRRow619 MemRRow655 1000.000000
R2655 MemRRow655 MemRRow692 1000.000000
R2692 MemRRow692 MemRRow730 1000.000000
R2730 MemRRow730 MemRRow769 1000.000000
R2769 MemRRow769 MemRRow809 1000.000000
R2809 MemRRow809 MemRRow850 1000.000000
R2850 MemRRow850 MemRRow892 1000.000000
R2892 MemRRow892 MemRRow935 1000.000000
R2935 MemRRow935 MemRRow979 1000.000000
R279 MemRRow79 MemRRow93 1000.000000
R293 MemRRow93 MemRRow108 1000.000000
R2108 MemRRow108 MemRRow124 1000.000000
R2124 MemRRow124 MemRRow141 1000.000000
R2141 MemRRow141 MemRRow159 1000.000000
R2159 MemRRow159 MemRRow178 1000.000000
R2178 MemRRow178 MemRRow198 1000.000000
R2198 MemRRow198 MemRRow219 1000.000000
R2219 MemRRow219 MemRRow241 1000.000000
R2241 MemRRow241 MemRRow264 1000.000000
R2264 MemRRow264 MemRRow288 1000.000000
R2288 MemRRow288 MemRRow313 1000.000000
R2313 MemRRow313 MemRRow339 1000.000000
R2339 MemRRow339 MemRRow366 1000.000000
R2366 MemRRow366 MemRRow394 1000.000000
R2394 MemRRow394 MemRRow423 1000.000000
R2423 MemRRow423 MemRRow453 1000.000000
R2453 MemRRow453 MemRRow484 1000.000000
R2484 MemRRow484 MemRRow516 1000.000000
R2516 MemRRow516 MemRRow549 1000.000000
R2549 MemRRow549 MemRRow583 1000.000000
R2583 MemRRow583 MemRRow618 1000.000000
R2618 MemRRow618 MemRRow654 1000.000000
R2654 MemRRow654 MemRRow691 1000.000000
R2691 MemRRow691 MemRRow729 1000.000000
R2729 MemRRow729 MemRRow768 1000.000000
R2768 MemRRow768 MemRRow808 1000.000000
R2808 MemRRow808 MemRRow849 1000.000000
R2849 MemRRow849 MemRRow891 1000.000000
R2891 MemRRow891 MemRRow934 1000.000000
R2934 MemRRow934 MemRRow978 1000.000000
R2978 MemRRow978 MemRRow1023 1000.000000
R292 MemRRow92 MemRRow107 1000.000000
R2107 MemRRow107 MemRRow123 1000.000000
R2123 MemRRow123 MemRRow140 1000.000000
R2140 MemRRow140 MemRRow158 1000.000000
R2158 MemRRow158 MemRRow177 1000.000000
R2177 MemRRow177 MemRRow197 1000.000000
R2197 MemRRow197 MemRRow218 1000.000000
R2218 MemRRow218 MemRRow240 1000.000000
R2240 MemRRow240 MemRRow263 1000.000000
R2263 MemRRow263 MemRRow287 1000.000000
R2287 MemRRow287 MemRRow312 1000.000000
R2312 MemRRow312 MemRRow338 1000.000000
R2338 MemRRow338 MemRRow365 1000.000000
R2365 MemRRow365 MemRRow393 1000.000000
R2393 MemRRow393 MemRRow422 1000.000000
R2422 MemRRow422 MemRRow452 1000.000000
R2452 MemRRow452 MemRRow483 1000.000000
R2483 MemRRow483 MemRRow515 1000.000000
R2515 MemRRow515 MemRRow548 1000.000000
R2548 MemRRow548 MemRRow582 1000.000000
R2582 MemRRow582 MemRRow617 1000.000000
R2617 MemRRow617 MemRRow653 1000.000000
R2653 MemRRow653 MemRRow690 1000.000000
R2690 MemRRow690 MemRRow728 1000.000000
R2728 MemRRow728 MemRRow767 1000.000000
R2767 MemRRow767 MemRRow807 1000.000000
R2807 MemRRow807 MemRRow848 1000.000000
R2848 MemRRow848 MemRRow890 1000.000000
R2890 MemRRow890 MemRRow933 1000.000000
R2933 MemRRow933 MemRRow977 1000.000000
R2977 MemRRow977 MemRRow1022 1000.000000
R21022 MemRRow1022 MemRRow1068 1000.000000
R2106 MemRRow106 MemRRow122 1000.000000
R2122 MemRRow122 MemRRow139 1000.000000
R2139 MemRRow139 MemRRow157 1000.000000
R2157 MemRRow157 MemRRow176 1000.000000
R2176 MemRRow176 MemRRow196 1000.000000
R2196 MemRRow196 MemRRow217 1000.000000
R2217 MemRRow217 MemRRow239 1000.000000
R2239 MemRRow239 MemRRow262 1000.000000
R2262 MemRRow262 MemRRow286 1000.000000
R2286 MemRRow286 MemRRow311 1000.000000
R2311 MemRRow311 MemRRow337 1000.000000
R2337 MemRRow337 MemRRow364 1000.000000
R2364 MemRRow364 MemRRow392 1000.000000
R2392 MemRRow392 MemRRow421 1000.000000
R2421 MemRRow421 MemRRow451 1000.000000
R2451 MemRRow451 MemRRow482 1000.000000
R2482 MemRRow482 MemRRow514 1000.000000
R2514 MemRRow514 MemRRow547 1000.000000
R2547 MemRRow547 MemRRow581 1000.000000
R2581 MemRRow581 MemRRow616 1000.000000
R2616 MemRRow616 MemRRow652 1000.000000
R2652 MemRRow652 MemRRow689 1000.000000
R2689 MemRRow689 MemRRow727 1000.000000
R2727 MemRRow727 MemRRow766 1000.000000
R2766 MemRRow766 MemRRow806 1000.000000
R2806 MemRRow806 MemRRow847 1000.000000
R2847 MemRRow847 MemRRow889 1000.000000
R2889 MemRRow889 MemRRow932 1000.000000
R2932 MemRRow932 MemRRow976 1000.000000
R2976 MemRRow976 MemRRow1021 1000.000000
R21021 MemRRow1021 MemRRow1067 1000.000000
R21067 MemRRow1067 MemRRow1114 1000.000000
R2121 MemRRow121 MemRRow138 1000.000000
R2138 MemRRow138 MemRRow156 1000.000000
R2156 MemRRow156 MemRRow175 1000.000000
R2175 MemRRow175 MemRRow195 1000.000000
R2195 MemRRow195 MemRRow216 1000.000000
R2216 MemRRow216 MemRRow238 1000.000000
R2238 MemRRow238 MemRRow261 1000.000000
R2261 MemRRow261 MemRRow285 1000.000000
R2285 MemRRow285 MemRRow310 1000.000000
R2310 MemRRow310 MemRRow336 1000.000000
R2336 MemRRow336 MemRRow363 1000.000000
R2363 MemRRow363 MemRRow391 1000.000000
R2391 MemRRow391 MemRRow420 1000.000000
R2420 MemRRow420 MemRRow450 1000.000000
R2450 MemRRow450 MemRRow481 1000.000000
R2481 MemRRow481 MemRRow513 1000.000000
R2513 MemRRow513 MemRRow546 1000.000000
R2546 MemRRow546 MemRRow580 1000.000000
R2580 MemRRow580 MemRRow615 1000.000000
R2615 MemRRow615 MemRRow651 1000.000000
R2651 MemRRow651 MemRRow688 1000.000000
R2688 MemRRow688 MemRRow726 1000.000000
R2726 MemRRow726 MemRRow765 1000.000000
R2765 MemRRow765 MemRRow805 1000.000000
R2805 MemRRow805 MemRRow846 1000.000000
R2846 MemRRow846 MemRRow888 1000.000000
R2888 MemRRow888 MemRRow931 1000.000000
R2931 MemRRow931 MemRRow975 1000.000000
R2975 MemRRow975 MemRRow1020 1000.000000
R21020 MemRRow1020 MemRRow1066 1000.000000
R21066 MemRRow1066 MemRRow1113 1000.000000
R21113 MemRRow1113 MemRRow1161 1000.000000
R2137 MemRRow137 MemRRow155 1000.000000
R2155 MemRRow155 MemRRow174 1000.000000
R2174 MemRRow174 MemRRow194 1000.000000
R2194 MemRRow194 MemRRow215 1000.000000
R2215 MemRRow215 MemRRow237 1000.000000
R2237 MemRRow237 MemRRow260 1000.000000
R2260 MemRRow260 MemRRow284 1000.000000
R2284 MemRRow284 MemRRow309 1000.000000
R2309 MemRRow309 MemRRow335 1000.000000
R2335 MemRRow335 MemRRow362 1000.000000
R2362 MemRRow362 MemRRow390 1000.000000
R2390 MemRRow390 MemRRow419 1000.000000
R2419 MemRRow419 MemRRow449 1000.000000
R2449 MemRRow449 MemRRow480 1000.000000
R2480 MemRRow480 MemRRow512 1000.000000
R2512 MemRRow512 MemRRow545 1000.000000
R2545 MemRRow545 MemRRow579 1000.000000
R2579 MemRRow579 MemRRow614 1000.000000
R2614 MemRRow614 MemRRow650 1000.000000
R2650 MemRRow650 MemRRow687 1000.000000
R2687 MemRRow687 MemRRow725 1000.000000
R2725 MemRRow725 MemRRow764 1000.000000
R2764 MemRRow764 MemRRow804 1000.000000
R2804 MemRRow804 MemRRow845 1000.000000
R2845 MemRRow845 MemRRow887 1000.000000
R2887 MemRRow887 MemRRow930 1000.000000
R2930 MemRRow930 MemRRow974 1000.000000
R2974 MemRRow974 MemRRow1019 1000.000000
R21019 MemRRow1019 MemRRow1065 1000.000000
R21065 MemRRow1065 MemRRow1112 1000.000000
R21112 MemRRow1112 MemRRow1160 1000.000000
R21160 MemRRow1160 MemRRow1209 1000.000000
R2154 MemRRow154 MemRRow173 1000.000000
R2173 MemRRow173 MemRRow193 1000.000000
R2193 MemRRow193 MemRRow214 1000.000000
R2214 MemRRow214 MemRRow236 1000.000000
R2236 MemRRow236 MemRRow259 1000.000000
R2259 MemRRow259 MemRRow283 1000.000000
R2283 MemRRow283 MemRRow308 1000.000000
R2308 MemRRow308 MemRRow334 1000.000000
R2334 MemRRow334 MemRRow361 1000.000000
R2361 MemRRow361 MemRRow389 1000.000000
R2389 MemRRow389 MemRRow418 1000.000000
R2418 MemRRow418 MemRRow448 1000.000000
R2448 MemRRow448 MemRRow479 1000.000000
R2479 MemRRow479 MemRRow511 1000.000000
R2511 MemRRow511 MemRRow544 1000.000000
R2544 MemRRow544 MemRRow578 1000.000000
R2578 MemRRow578 MemRRow613 1000.000000
R2613 MemRRow613 MemRRow649 1000.000000
R2649 MemRRow649 MemRRow686 1000.000000
R2686 MemRRow686 MemRRow724 1000.000000
R2724 MemRRow724 MemRRow763 1000.000000
R2763 MemRRow763 MemRRow803 1000.000000
R2803 MemRRow803 MemRRow844 1000.000000
R2844 MemRRow844 MemRRow886 1000.000000
R2886 MemRRow886 MemRRow929 1000.000000
R2929 MemRRow929 MemRRow973 1000.000000
R2973 MemRRow973 MemRRow1018 1000.000000
R21018 MemRRow1018 MemRRow1064 1000.000000
R21064 MemRRow1064 MemRRow1111 1000.000000
R21111 MemRRow1111 MemRRow1159 1000.000000
R21159 MemRRow1159 MemRRow1208 1000.000000
R21208 MemRRow1208 MemRRow1258 1000.000000
R2172 MemRRow172 MemRRow192 1000.000000
R2192 MemRRow192 MemRRow213 1000.000000
R2213 MemRRow213 MemRRow235 1000.000000
R2235 MemRRow235 MemRRow258 1000.000000
R2258 MemRRow258 MemRRow282 1000.000000
R2282 MemRRow282 MemRRow307 1000.000000
R2307 MemRRow307 MemRRow333 1000.000000
R2333 MemRRow333 MemRRow360 1000.000000
R2360 MemRRow360 MemRRow388 1000.000000
R2388 MemRRow388 MemRRow417 1000.000000
R2417 MemRRow417 MemRRow447 1000.000000
R2447 MemRRow447 MemRRow478 1000.000000
R2478 MemRRow478 MemRRow510 1000.000000
R2510 MemRRow510 MemRRow543 1000.000000
R2543 MemRRow543 MemRRow577 1000.000000
R2577 MemRRow577 MemRRow612 1000.000000
R2612 MemRRow612 MemRRow648 1000.000000
R2648 MemRRow648 MemRRow685 1000.000000
R2685 MemRRow685 MemRRow723 1000.000000
R2723 MemRRow723 MemRRow762 1000.000000
R2762 MemRRow762 MemRRow802 1000.000000
R2802 MemRRow802 MemRRow843 1000.000000
R2843 MemRRow843 MemRRow885 1000.000000
R2885 MemRRow885 MemRRow928 1000.000000
R2928 MemRRow928 MemRRow972 1000.000000
R2972 MemRRow972 MemRRow1017 1000.000000
R21017 MemRRow1017 MemRRow1063 1000.000000
R21063 MemRRow1063 MemRRow1110 1000.000000
R21110 MemRRow1110 MemRRow1158 1000.000000
R21158 MemRRow1158 MemRRow1207 1000.000000
R21207 MemRRow1207 MemRRow1257 1000.000000
R21257 MemRRow1257 MemRRow1308 1000.000000
R2191 MemRRow191 MemRRow212 1000.000000
R2212 MemRRow212 MemRRow234 1000.000000
R2234 MemRRow234 MemRRow257 1000.000000
R2257 MemRRow257 MemRRow281 1000.000000
R2281 MemRRow281 MemRRow306 1000.000000
R2306 MemRRow306 MemRRow332 1000.000000
R2332 MemRRow332 MemRRow359 1000.000000
R2359 MemRRow359 MemRRow387 1000.000000
R2387 MemRRow387 MemRRow416 1000.000000
R2416 MemRRow416 MemRRow446 1000.000000
R2446 MemRRow446 MemRRow477 1000.000000
R2477 MemRRow477 MemRRow509 1000.000000
R2509 MemRRow509 MemRRow542 1000.000000
R2542 MemRRow542 MemRRow576 1000.000000
R2576 MemRRow576 MemRRow611 1000.000000
R2611 MemRRow611 MemRRow647 1000.000000
R2647 MemRRow647 MemRRow684 1000.000000
R2684 MemRRow684 MemRRow722 1000.000000
R2722 MemRRow722 MemRRow761 1000.000000
R2761 MemRRow761 MemRRow801 1000.000000
R2801 MemRRow801 MemRRow842 1000.000000
R2842 MemRRow842 MemRRow884 1000.000000
R2884 MemRRow884 MemRRow927 1000.000000
R2927 MemRRow927 MemRRow971 1000.000000
R2971 MemRRow971 MemRRow1016 1000.000000
R21016 MemRRow1016 MemRRow1062 1000.000000
R21062 MemRRow1062 MemRRow1109 1000.000000
R21109 MemRRow1109 MemRRow1157 1000.000000
R21157 MemRRow1157 MemRRow1206 1000.000000
R21206 MemRRow1206 MemRRow1256 1000.000000
R21256 MemRRow1256 MemRRow1307 1000.000000
R21307 MemRRow1307 MemRRow1359 1000.000000
R2211 MemRRow211 MemRRow233 1000.000000
R2233 MemRRow233 MemRRow256 1000.000000
R2256 MemRRow256 MemRRow280 1000.000000
R2280 MemRRow280 MemRRow305 1000.000000
R2305 MemRRow305 MemRRow331 1000.000000
R2331 MemRRow331 MemRRow358 1000.000000
R2358 MemRRow358 MemRRow386 1000.000000
R2386 MemRRow386 MemRRow415 1000.000000
R2415 MemRRow415 MemRRow445 1000.000000
R2445 MemRRow445 MemRRow476 1000.000000
R2476 MemRRow476 MemRRow508 1000.000000
R2508 MemRRow508 MemRRow541 1000.000000
R2541 MemRRow541 MemRRow575 1000.000000
R2575 MemRRow575 MemRRow610 1000.000000
R2610 MemRRow610 MemRRow646 1000.000000
R2646 MemRRow646 MemRRow683 1000.000000
R2683 MemRRow683 MemRRow721 1000.000000
R2721 MemRRow721 MemRRow760 1000.000000
R2760 MemRRow760 MemRRow800 1000.000000
R2800 MemRRow800 MemRRow841 1000.000000
R2841 MemRRow841 MemRRow883 1000.000000
R2883 MemRRow883 MemRRow926 1000.000000
R2926 MemRRow926 MemRRow970 1000.000000
R2970 MemRRow970 MemRRow1015 1000.000000
R21015 MemRRow1015 MemRRow1061 1000.000000
R21061 MemRRow1061 MemRRow1108 1000.000000
R21108 MemRRow1108 MemRRow1156 1000.000000
R21156 MemRRow1156 MemRRow1205 1000.000000
R21205 MemRRow1205 MemRRow1255 1000.000000
R21255 MemRRow1255 MemRRow1306 1000.000000
R21306 MemRRow1306 MemRRow1358 1000.000000
R21358 MemRRow1358 MemRRow1411 1000.000000
R2232 MemRRow232 MemRRow255 1000.000000
R2255 MemRRow255 MemRRow279 1000.000000
R2279 MemRRow279 MemRRow304 1000.000000
R2304 MemRRow304 MemRRow330 1000.000000
R2330 MemRRow330 MemRRow357 1000.000000
R2357 MemRRow357 MemRRow385 1000.000000
R2385 MemRRow385 MemRRow414 1000.000000
R2414 MemRRow414 MemRRow444 1000.000000
R2444 MemRRow444 MemRRow475 1000.000000
R2475 MemRRow475 MemRRow507 1000.000000
R2507 MemRRow507 MemRRow540 1000.000000
R2540 MemRRow540 MemRRow574 1000.000000
R2574 MemRRow574 MemRRow609 1000.000000
R2609 MemRRow609 MemRRow645 1000.000000
R2645 MemRRow645 MemRRow682 1000.000000
R2682 MemRRow682 MemRRow720 1000.000000
R2720 MemRRow720 MemRRow759 1000.000000
R2759 MemRRow759 MemRRow799 1000.000000
R2799 MemRRow799 MemRRow840 1000.000000
R2840 MemRRow840 MemRRow882 1000.000000
R2882 MemRRow882 MemRRow925 1000.000000
R2925 MemRRow925 MemRRow969 1000.000000
R2969 MemRRow969 MemRRow1014 1000.000000
R21014 MemRRow1014 MemRRow1060 1000.000000
R21060 MemRRow1060 MemRRow1107 1000.000000
R21107 MemRRow1107 MemRRow1155 1000.000000
R21155 MemRRow1155 MemRRow1204 1000.000000
R21204 MemRRow1204 MemRRow1254 1000.000000
R21254 MemRRow1254 MemRRow1305 1000.000000
R21305 MemRRow1305 MemRRow1357 1000.000000
R21357 MemRRow1357 MemRRow1410 1000.000000
R21410 MemRRow1410 MemRRow1464 1000.000000
R2254 MemRRow254 MemRRow278 1000.000000
R2278 MemRRow278 MemRRow303 1000.000000
R2303 MemRRow303 MemRRow329 1000.000000
R2329 MemRRow329 MemRRow356 1000.000000
R2356 MemRRow356 MemRRow384 1000.000000
R2384 MemRRow384 MemRRow413 1000.000000
R2413 MemRRow413 MemRRow443 1000.000000
R2443 MemRRow443 MemRRow474 1000.000000
R2474 MemRRow474 MemRRow506 1000.000000
R2506 MemRRow506 MemRRow539 1000.000000
R2539 MemRRow539 MemRRow573 1000.000000
R2573 MemRRow573 MemRRow608 1000.000000
R2608 MemRRow608 MemRRow644 1000.000000
R2644 MemRRow644 MemRRow681 1000.000000
R2681 MemRRow681 MemRRow719 1000.000000
R2719 MemRRow719 MemRRow758 1000.000000
R2758 MemRRow758 MemRRow798 1000.000000
R2798 MemRRow798 MemRRow839 1000.000000
R2839 MemRRow839 MemRRow881 1000.000000
R2881 MemRRow881 MemRRow924 1000.000000
R2924 MemRRow924 MemRRow968 1000.000000
R2968 MemRRow968 MemRRow1013 1000.000000
R21013 MemRRow1013 MemRRow1059 1000.000000
R21059 MemRRow1059 MemRRow1106 1000.000000
R21106 MemRRow1106 MemRRow1154 1000.000000
R21154 MemRRow1154 MemRRow1203 1000.000000
R21203 MemRRow1203 MemRRow1253 1000.000000
R21253 MemRRow1253 MemRRow1304 1000.000000
R21304 MemRRow1304 MemRRow1356 1000.000000
R21356 MemRRow1356 MemRRow1409 1000.000000
R21409 MemRRow1409 MemRRow1463 1000.000000
R21463 MemRRow1463 MemRRow1518 1000.000000
R2277 MemRRow277 MemRRow302 1000.000000
R2302 MemRRow302 MemRRow328 1000.000000
R2328 MemRRow328 MemRRow355 1000.000000
R2355 MemRRow355 MemRRow383 1000.000000
R2383 MemRRow383 MemRRow412 1000.000000
R2412 MemRRow412 MemRRow442 1000.000000
R2442 MemRRow442 MemRRow473 1000.000000
R2473 MemRRow473 MemRRow505 1000.000000
R2505 MemRRow505 MemRRow538 1000.000000
R2538 MemRRow538 MemRRow572 1000.000000
R2572 MemRRow572 MemRRow607 1000.000000
R2607 MemRRow607 MemRRow643 1000.000000
R2643 MemRRow643 MemRRow680 1000.000000
R2680 MemRRow680 MemRRow718 1000.000000
R2718 MemRRow718 MemRRow757 1000.000000
R2757 MemRRow757 MemRRow797 1000.000000
R2797 MemRRow797 MemRRow838 1000.000000
R2838 MemRRow838 MemRRow880 1000.000000
R2880 MemRRow880 MemRRow923 1000.000000
R2923 MemRRow923 MemRRow967 1000.000000
R2967 MemRRow967 MemRRow1012 1000.000000
R21012 MemRRow1012 MemRRow1058 1000.000000
R21058 MemRRow1058 MemRRow1105 1000.000000
R21105 MemRRow1105 MemRRow1153 1000.000000
R21153 MemRRow1153 MemRRow1202 1000.000000
R21202 MemRRow1202 MemRRow1252 1000.000000
R21252 MemRRow1252 MemRRow1303 1000.000000
R21303 MemRRow1303 MemRRow1355 1000.000000
R21355 MemRRow1355 MemRRow1408 1000.000000
R21408 MemRRow1408 MemRRow1462 1000.000000
R21462 MemRRow1462 MemRRow1517 1000.000000
R21517 MemRRow1517 MemRRow1573 1000.000000
R2301 MemRRow301 MemRRow327 1000.000000
R2327 MemRRow327 MemRRow354 1000.000000
R2354 MemRRow354 MemRRow382 1000.000000
R2382 MemRRow382 MemRRow411 1000.000000
R2411 MemRRow411 MemRRow441 1000.000000
R2441 MemRRow441 MemRRow472 1000.000000
R2472 MemRRow472 MemRRow504 1000.000000
R2504 MemRRow504 MemRRow537 1000.000000
R2537 MemRRow537 MemRRow571 1000.000000
R2571 MemRRow571 MemRRow606 1000.000000
R2606 MemRRow606 MemRRow642 1000.000000
R2642 MemRRow642 MemRRow679 1000.000000
R2679 MemRRow679 MemRRow717 1000.000000
R2717 MemRRow717 MemRRow756 1000.000000
R2756 MemRRow756 MemRRow796 1000.000000
R2796 MemRRow796 MemRRow837 1000.000000
R2837 MemRRow837 MemRRow879 1000.000000
R2879 MemRRow879 MemRRow922 1000.000000
R2922 MemRRow922 MemRRow966 1000.000000
R2966 MemRRow966 MemRRow1011 1000.000000
R21011 MemRRow1011 MemRRow1057 1000.000000
R21057 MemRRow1057 MemRRow1104 1000.000000
R21104 MemRRow1104 MemRRow1152 1000.000000
R21152 MemRRow1152 MemRRow1201 1000.000000
R21201 MemRRow1201 MemRRow1251 1000.000000
R21251 MemRRow1251 MemRRow1302 1000.000000
R21302 MemRRow1302 MemRRow1354 1000.000000
R21354 MemRRow1354 MemRRow1407 1000.000000
R21407 MemRRow1407 MemRRow1461 1000.000000
R21461 MemRRow1461 MemRRow1516 1000.000000
R21516 MemRRow1516 MemRRow1572 1000.000000
R21572 MemRRow1572 MemRRow1629 1000.000000
R2326 MemRRow326 MemRRow353 1000.000000
R2353 MemRRow353 MemRRow381 1000.000000
R2381 MemRRow381 MemRRow410 1000.000000
R2410 MemRRow410 MemRRow440 1000.000000
R2440 MemRRow440 MemRRow471 1000.000000
R2471 MemRRow471 MemRRow503 1000.000000
R2503 MemRRow503 MemRRow536 1000.000000
R2536 MemRRow536 MemRRow570 1000.000000
R2570 MemRRow570 MemRRow605 1000.000000
R2605 MemRRow605 MemRRow641 1000.000000
R2641 MemRRow641 MemRRow678 1000.000000
R2678 MemRRow678 MemRRow716 1000.000000
R2716 MemRRow716 MemRRow755 1000.000000
R2755 MemRRow755 MemRRow795 1000.000000
R2795 MemRRow795 MemRRow836 1000.000000
R2836 MemRRow836 MemRRow878 1000.000000
R2878 MemRRow878 MemRRow921 1000.000000
R2921 MemRRow921 MemRRow965 1000.000000
R2965 MemRRow965 MemRRow1010 1000.000000
R21010 MemRRow1010 MemRRow1056 1000.000000
R21056 MemRRow1056 MemRRow1103 1000.000000
R21103 MemRRow1103 MemRRow1151 1000.000000
R21151 MemRRow1151 MemRRow1200 1000.000000
R21200 MemRRow1200 MemRRow1250 1000.000000
R21250 MemRRow1250 MemRRow1301 1000.000000
R21301 MemRRow1301 MemRRow1353 1000.000000
R21353 MemRRow1353 MemRRow1406 1000.000000
R21406 MemRRow1406 MemRRow1460 1000.000000
R21460 MemRRow1460 MemRRow1515 1000.000000
R21515 MemRRow1515 MemRRow1571 1000.000000
R21571 MemRRow1571 MemRRow1628 1000.000000
R21628 MemRRow1628 MemRRow1686 1000.000000
R2352 MemRRow352 MemRRow380 1000.000000
R2380 MemRRow380 MemRRow409 1000.000000
R2409 MemRRow409 MemRRow439 1000.000000
R2439 MemRRow439 MemRRow470 1000.000000
R2470 MemRRow470 MemRRow502 1000.000000
R2502 MemRRow502 MemRRow535 1000.000000
R2535 MemRRow535 MemRRow569 1000.000000
R2569 MemRRow569 MemRRow604 1000.000000
R2604 MemRRow604 MemRRow640 1000.000000
R2640 MemRRow640 MemRRow677 1000.000000
R2677 MemRRow677 MemRRow715 1000.000000
R2715 MemRRow715 MemRRow754 1000.000000
R2754 MemRRow754 MemRRow794 1000.000000
R2794 MemRRow794 MemRRow835 1000.000000
R2835 MemRRow835 MemRRow877 1000.000000
R2877 MemRRow877 MemRRow920 1000.000000
R2920 MemRRow920 MemRRow964 1000.000000
R2964 MemRRow964 MemRRow1009 1000.000000
R21009 MemRRow1009 MemRRow1055 1000.000000
R21055 MemRRow1055 MemRRow1102 1000.000000
R21102 MemRRow1102 MemRRow1150 1000.000000
R21150 MemRRow1150 MemRRow1199 1000.000000
R21199 MemRRow1199 MemRRow1249 1000.000000
R21249 MemRRow1249 MemRRow1300 1000.000000
R21300 MemRRow1300 MemRRow1352 1000.000000
R21352 MemRRow1352 MemRRow1405 1000.000000
R21405 MemRRow1405 MemRRow1459 1000.000000
R21459 MemRRow1459 MemRRow1514 1000.000000
R21514 MemRRow1514 MemRRow1570 1000.000000
R21570 MemRRow1570 MemRRow1627 1000.000000
R21627 MemRRow1627 MemRRow1685 1000.000000
R21685 MemRRow1685 MemRRow1744 1000.000000
R2379 MemRRow379 MemRRow408 1000.000000
R2408 MemRRow408 MemRRow438 1000.000000
R2438 MemRRow438 MemRRow469 1000.000000
R2469 MemRRow469 MemRRow501 1000.000000
R2501 MemRRow501 MemRRow534 1000.000000
R2534 MemRRow534 MemRRow568 1000.000000
R2568 MemRRow568 MemRRow603 1000.000000
R2603 MemRRow603 MemRRow639 1000.000000
R2639 MemRRow639 MemRRow676 1000.000000
R2676 MemRRow676 MemRRow714 1000.000000
R2714 MemRRow714 MemRRow753 1000.000000
R2753 MemRRow753 MemRRow793 1000.000000
R2793 MemRRow793 MemRRow834 1000.000000
R2834 MemRRow834 MemRRow876 1000.000000
R2876 MemRRow876 MemRRow919 1000.000000
R2919 MemRRow919 MemRRow963 1000.000000
R2963 MemRRow963 MemRRow1008 1000.000000
R21008 MemRRow1008 MemRRow1054 1000.000000
R21054 MemRRow1054 MemRRow1101 1000.000000
R21101 MemRRow1101 MemRRow1149 1000.000000
R21149 MemRRow1149 MemRRow1198 1000.000000
R21198 MemRRow1198 MemRRow1248 1000.000000
R21248 MemRRow1248 MemRRow1299 1000.000000
R21299 MemRRow1299 MemRRow1351 1000.000000
R21351 MemRRow1351 MemRRow1404 1000.000000
R21404 MemRRow1404 MemRRow1458 1000.000000
R21458 MemRRow1458 MemRRow1513 1000.000000
R21513 MemRRow1513 MemRRow1569 1000.000000
R21569 MemRRow1569 MemRRow1626 1000.000000
R21626 MemRRow1626 MemRRow1684 1000.000000
R21684 MemRRow1684 MemRRow1743 1000.000000
R21743 MemRRow1743 MemRRow1803 1000.000000
R2407 MemRRow407 MemRRow437 1000.000000
R2437 MemRRow437 MemRRow468 1000.000000
R2468 MemRRow468 MemRRow500 1000.000000
R2500 MemRRow500 MemRRow533 1000.000000
R2533 MemRRow533 MemRRow567 1000.000000
R2567 MemRRow567 MemRRow602 1000.000000
R2602 MemRRow602 MemRRow638 1000.000000
R2638 MemRRow638 MemRRow675 1000.000000
R2675 MemRRow675 MemRRow713 1000.000000
R2713 MemRRow713 MemRRow752 1000.000000
R2752 MemRRow752 MemRRow792 1000.000000
R2792 MemRRow792 MemRRow833 1000.000000
R2833 MemRRow833 MemRRow875 1000.000000
R2875 MemRRow875 MemRRow918 1000.000000
R2918 MemRRow918 MemRRow962 1000.000000
R2962 MemRRow962 MemRRow1007 1000.000000
R21007 MemRRow1007 MemRRow1053 1000.000000
R21053 MemRRow1053 MemRRow1100 1000.000000
R21100 MemRRow1100 MemRRow1148 1000.000000
R21148 MemRRow1148 MemRRow1197 1000.000000
R21197 MemRRow1197 MemRRow1247 1000.000000
R21247 MemRRow1247 MemRRow1298 1000.000000
R21298 MemRRow1298 MemRRow1350 1000.000000
R21350 MemRRow1350 MemRRow1403 1000.000000
R21403 MemRRow1403 MemRRow1457 1000.000000
R21457 MemRRow1457 MemRRow1512 1000.000000
R21512 MemRRow1512 MemRRow1568 1000.000000
R21568 MemRRow1568 MemRRow1625 1000.000000
R21625 MemRRow1625 MemRRow1683 1000.000000
R21683 MemRRow1683 MemRRow1742 1000.000000
R21742 MemRRow1742 MemRRow1802 1000.000000
R21802 MemRRow1802 MemRRow1863 1000.000000
R2436 MemRRow436 MemRRow467 1000.000000
R2467 MemRRow467 MemRRow499 1000.000000
R2499 MemRRow499 MemRRow532 1000.000000
R2532 MemRRow532 MemRRow566 1000.000000
R2566 MemRRow566 MemRRow601 1000.000000
R2601 MemRRow601 MemRRow637 1000.000000
R2637 MemRRow637 MemRRow674 1000.000000
R2674 MemRRow674 MemRRow712 1000.000000
R2712 MemRRow712 MemRRow751 1000.000000
R2751 MemRRow751 MemRRow791 1000.000000
R2791 MemRRow791 MemRRow832 1000.000000
R2832 MemRRow832 MemRRow874 1000.000000
R2874 MemRRow874 MemRRow917 1000.000000
R2917 MemRRow917 MemRRow961 1000.000000
R2961 MemRRow961 MemRRow1006 1000.000000
R21006 MemRRow1006 MemRRow1052 1000.000000
R21052 MemRRow1052 MemRRow1099 1000.000000
R21099 MemRRow1099 MemRRow1147 1000.000000
R21147 MemRRow1147 MemRRow1196 1000.000000
R21196 MemRRow1196 MemRRow1246 1000.000000
R21246 MemRRow1246 MemRRow1297 1000.000000
R21297 MemRRow1297 MemRRow1349 1000.000000
R21349 MemRRow1349 MemRRow1402 1000.000000
R21402 MemRRow1402 MemRRow1456 1000.000000
R21456 MemRRow1456 MemRRow1511 1000.000000
R21511 MemRRow1511 MemRRow1567 1000.000000
R21567 MemRRow1567 MemRRow1624 1000.000000
R21624 MemRRow1624 MemRRow1682 1000.000000
R21682 MemRRow1682 MemRRow1741 1000.000000
R21741 MemRRow1741 MemRRow1801 1000.000000
R21801 MemRRow1801 MemRRow1862 1000.000000
R21862 MemRRow1862 MemRRow1924 1000.000000
R2466 MemRRow466 MemRRow498 1000.000000
R2498 MemRRow498 MemRRow531 1000.000000
R2531 MemRRow531 MemRRow565 1000.000000
R2565 MemRRow565 MemRRow600 1000.000000
R2600 MemRRow600 MemRRow636 1000.000000
R2636 MemRRow636 MemRRow673 1000.000000
R2673 MemRRow673 MemRRow711 1000.000000
R2711 MemRRow711 MemRRow750 1000.000000
R2750 MemRRow750 MemRRow790 1000.000000
R2790 MemRRow790 MemRRow831 1000.000000
R2831 MemRRow831 MemRRow873 1000.000000
R2873 MemRRow873 MemRRow916 1000.000000
R2916 MemRRow916 MemRRow960 1000.000000
R2960 MemRRow960 MemRRow1005 1000.000000
R21005 MemRRow1005 MemRRow1051 1000.000000
R21051 MemRRow1051 MemRRow1098 1000.000000
R21098 MemRRow1098 MemRRow1146 1000.000000
R21146 MemRRow1146 MemRRow1195 1000.000000
R21195 MemRRow1195 MemRRow1245 1000.000000
R21245 MemRRow1245 MemRRow1296 1000.000000
R21296 MemRRow1296 MemRRow1348 1000.000000
R21348 MemRRow1348 MemRRow1401 1000.000000
R21401 MemRRow1401 MemRRow1455 1000.000000
R21455 MemRRow1455 MemRRow1510 1000.000000
R21510 MemRRow1510 MemRRow1566 1000.000000
R21566 MemRRow1566 MemRRow1623 1000.000000
R21623 MemRRow1623 MemRRow1681 1000.000000
R21681 MemRRow1681 MemRRow1740 1000.000000
R21740 MemRRow1740 MemRRow1800 1000.000000
R21800 MemRRow1800 MemRRow1861 1000.000000
R21861 MemRRow1861 MemRRow1923 1000.000000
R21923 MemRRow1923 MemRRow1986 1000.000000
R2497 MemRRow497 MemRRow530 1000.000000
R2530 MemRRow530 MemRRow564 1000.000000
R2564 MemRRow564 MemRRow599 1000.000000
R2599 MemRRow599 MemRRow635 1000.000000
R2635 MemRRow635 MemRRow672 1000.000000
R2672 MemRRow672 MemRRow710 1000.000000
R2710 MemRRow710 MemRRow749 1000.000000
R2749 MemRRow749 MemRRow789 1000.000000
R2789 MemRRow789 MemRRow830 1000.000000
R2830 MemRRow830 MemRRow872 1000.000000
R2872 MemRRow872 MemRRow915 1000.000000
R2915 MemRRow915 MemRRow959 1000.000000
R2959 MemRRow959 MemRRow1004 1000.000000
R21004 MemRRow1004 MemRRow1050 1000.000000
R21050 MemRRow1050 MemRRow1097 1000.000000
R21097 MemRRow1097 MemRRow1145 1000.000000
R21145 MemRRow1145 MemRRow1194 1000.000000
R21194 MemRRow1194 MemRRow1244 1000.000000
R21244 MemRRow1244 MemRRow1295 1000.000000
R21295 MemRRow1295 MemRRow1347 1000.000000
R21347 MemRRow1347 MemRRow1400 1000.000000
R21400 MemRRow1400 MemRRow1454 1000.000000
R21454 MemRRow1454 MemRRow1509 1000.000000
R21509 MemRRow1509 MemRRow1565 1000.000000
R21565 MemRRow1565 MemRRow1622 1000.000000
R21622 MemRRow1622 MemRRow1680 1000.000000
R21680 MemRRow1680 MemRRow1739 1000.000000
R21739 MemRRow1739 MemRRow1799 1000.000000
R21799 MemRRow1799 MemRRow1860 1000.000000
R21860 MemRRow1860 MemRRow1922 1000.000000
R21922 MemRRow1922 MemRRow1985 1000.000000
R21985 MemRRow1985 MemRRow2049 1000.000000
R2529 MemRRow529 MemRRow563 1000.000000
R2563 MemRRow563 MemRRow598 1000.000000
R2598 MemRRow598 MemRRow634 1000.000000
R2634 MemRRow634 MemRRow671 1000.000000
R2671 MemRRow671 MemRRow709 1000.000000
R2709 MemRRow709 MemRRow748 1000.000000
R2748 MemRRow748 MemRRow788 1000.000000
R2788 MemRRow788 MemRRow829 1000.000000
R2829 MemRRow829 MemRRow871 1000.000000
R2871 MemRRow871 MemRRow914 1000.000000
R2914 MemRRow914 MemRRow958 1000.000000
R2958 MemRRow958 MemRRow1003 1000.000000
R21003 MemRRow1003 MemRRow1049 1000.000000
R21049 MemRRow1049 MemRRow1096 1000.000000
R21096 MemRRow1096 MemRRow1144 1000.000000
R21144 MemRRow1144 MemRRow1193 1000.000000
R21193 MemRRow1193 MemRRow1243 1000.000000
R21243 MemRRow1243 MemRRow1294 1000.000000
R21294 MemRRow1294 MemRRow1346 1000.000000
R21346 MemRRow1346 MemRRow1399 1000.000000
R21399 MemRRow1399 MemRRow1453 1000.000000
R21453 MemRRow1453 MemRRow1508 1000.000000
R21508 MemRRow1508 MemRRow1564 1000.000000
R21564 MemRRow1564 MemRRow1621 1000.000000
R21621 MemRRow1621 MemRRow1679 1000.000000
R21679 MemRRow1679 MemRRow1738 1000.000000
R21738 MemRRow1738 MemRRow1798 1000.000000
R21798 MemRRow1798 MemRRow1859 1000.000000
R21859 MemRRow1859 MemRRow1921 1000.000000
R21921 MemRRow1921 MemRRow1984 1000.000000
R21984 MemRRow1984 MemRRow2048 1000.000000
R22048 MemRRow2048 MemRRow2113 1000.000000
R2562 MemRRow562 MemRRow597 1000.000000
R2597 MemRRow597 MemRRow633 1000.000000
R2633 MemRRow633 MemRRow670 1000.000000
R2670 MemRRow670 MemRRow708 1000.000000
R2708 MemRRow708 MemRRow747 1000.000000
R2747 MemRRow747 MemRRow787 1000.000000
R2787 MemRRow787 MemRRow828 1000.000000
R2828 MemRRow828 MemRRow870 1000.000000
R2870 MemRRow870 MemRRow913 1000.000000
R2913 MemRRow913 MemRRow957 1000.000000
R2957 MemRRow957 MemRRow1002 1000.000000
R21002 MemRRow1002 MemRRow1048 1000.000000
R21048 MemRRow1048 MemRRow1095 1000.000000
R21095 MemRRow1095 MemRRow1143 1000.000000
R21143 MemRRow1143 MemRRow1192 1000.000000
R21192 MemRRow1192 MemRRow1242 1000.000000
R21242 MemRRow1242 MemRRow1293 1000.000000
R21293 MemRRow1293 MemRRow1345 1000.000000
R21345 MemRRow1345 MemRRow1398 1000.000000
R21398 MemRRow1398 MemRRow1452 1000.000000
R21452 MemRRow1452 MemRRow1507 1000.000000
R21507 MemRRow1507 MemRRow1563 1000.000000
R21563 MemRRow1563 MemRRow1620 1000.000000
R21620 MemRRow1620 MemRRow1678 1000.000000
R21678 MemRRow1678 MemRRow1737 1000.000000
R21737 MemRRow1737 MemRRow1797 1000.000000
R21797 MemRRow1797 MemRRow1858 1000.000000
R21858 MemRRow1858 MemRRow1920 1000.000000
R21920 MemRRow1920 MemRRow1983 1000.000000
R21983 MemRRow1983 MemRRow2047 1000.000000
R22047 MemRRow2047 MemRRow2112 1000.000000
R22112 MemRRow2112 MemRRow2178 1000.000000

*Line Column Resistances
R34 MemRCol4 MemRCol7 1000.000000
R38 MemRCol8 MemRCol12 1000.000000
R313 MemRCol13 MemRCol18 1000.000000
R319 MemRCol19 MemRCol25 1000.000000
R326 MemRCol26 MemRCol33 1000.000000
R334 MemRCol34 MemRCol42 1000.000000
R343 MemRCol43 MemRCol52 1000.000000
R353 MemRCol53 MemRCol63 1000.000000
R364 MemRCol64 MemRCol75 1000.000000
R376 MemRCol76 MemRCol88 1000.000000
R389 MemRCol89 MemRCol102 1000.000000
R3103 MemRCol103 MemRCol117 1000.000000
R3118 MemRCol118 MemRCol133 1000.000000
R3134 MemRCol134 MemRCol150 1000.000000
R3151 MemRCol151 MemRCol168 1000.000000
R3169 MemRCol169 MemRCol187 1000.000000
R3188 MemRCol188 MemRCol207 1000.000000
R3208 MemRCol208 MemRCol228 1000.000000
R3229 MemRCol229 MemRCol250 1000.000000
R3251 MemRCol251 MemRCol273 1000.000000
R3274 MemRCol274 MemRCol297 1000.000000
R3298 MemRCol298 MemRCol322 1000.000000
R3323 MemRCol323 MemRCol348 1000.000000
R3349 MemRCol349 MemRCol375 1000.000000
R3376 MemRCol376 MemRCol403 1000.000000
R3404 MemRCol404 MemRCol432 1000.000000
R3433 MemRCol433 MemRCol462 1000.000000
R3463 MemRCol463 MemRCol493 1000.000000
R3494 MemRCol494 MemRCol525 1000.000000
R3526 MemRCol526 MemRCol558 1000.000000
R3559 MemRCol559 MemRCol592 1000.000000
R3593 MemRCol593 MemRCol627 1000.000000
R37 MemRCol7 MemRCol11 1000.000000
R312 MemRCol12 MemRCol17 1000.000000
R318 MemRCol18 MemRCol24 1000.000000
R325 MemRCol25 MemRCol32 1000.000000
R333 MemRCol33 MemRCol41 1000.000000
R342 MemRCol42 MemRCol51 1000.000000
R352 MemRCol52 MemRCol62 1000.000000
R363 MemRCol63 MemRCol74 1000.000000
R375 MemRCol75 MemRCol87 1000.000000
R388 MemRCol88 MemRCol101 1000.000000
R3102 MemRCol102 MemRCol116 1000.000000
R3117 MemRCol117 MemRCol132 1000.000000
R3133 MemRCol133 MemRCol149 1000.000000
R3150 MemRCol150 MemRCol167 1000.000000
R3168 MemRCol168 MemRCol186 1000.000000
R3187 MemRCol187 MemRCol206 1000.000000
R3207 MemRCol207 MemRCol227 1000.000000
R3228 MemRCol228 MemRCol249 1000.000000
R3250 MemRCol250 MemRCol272 1000.000000
R3273 MemRCol273 MemRCol296 1000.000000
R3297 MemRCol297 MemRCol321 1000.000000
R3322 MemRCol322 MemRCol347 1000.000000
R3348 MemRCol348 MemRCol374 1000.000000
R3375 MemRCol375 MemRCol402 1000.000000
R3403 MemRCol403 MemRCol431 1000.000000
R3432 MemRCol432 MemRCol461 1000.000000
R3462 MemRCol462 MemRCol492 1000.000000
R3493 MemRCol493 MemRCol524 1000.000000
R3525 MemRCol525 MemRCol557 1000.000000
R3558 MemRCol558 MemRCol591 1000.000000
R3592 MemRCol592 MemRCol626 1000.000000
R3627 MemRCol627 MemRCol662 1000.000000
R311 MemRCol11 MemRCol16 1000.000000
R317 MemRCol17 MemRCol23 1000.000000
R324 MemRCol24 MemRCol31 1000.000000
R332 MemRCol32 MemRCol40 1000.000000
R341 MemRCol41 MemRCol50 1000.000000
R351 MemRCol51 MemRCol61 1000.000000
R362 MemRCol62 MemRCol73 1000.000000
R374 MemRCol74 MemRCol86 1000.000000
R387 MemRCol87 MemRCol100 1000.000000
R3101 MemRCol101 MemRCol115 1000.000000
R3116 MemRCol116 MemRCol131 1000.000000
R3132 MemRCol132 MemRCol148 1000.000000
R3149 MemRCol149 MemRCol166 1000.000000
R3167 MemRCol167 MemRCol185 1000.000000
R3186 MemRCol186 MemRCol205 1000.000000
R3206 MemRCol206 MemRCol226 1000.000000
R3227 MemRCol227 MemRCol248 1000.000000
R3249 MemRCol249 MemRCol271 1000.000000
R3272 MemRCol272 MemRCol295 1000.000000
R3296 MemRCol296 MemRCol320 1000.000000
R3321 MemRCol321 MemRCol346 1000.000000
R3347 MemRCol347 MemRCol373 1000.000000
R3374 MemRCol374 MemRCol401 1000.000000
R3402 MemRCol402 MemRCol430 1000.000000
R3431 MemRCol431 MemRCol460 1000.000000
R3461 MemRCol461 MemRCol491 1000.000000
R3492 MemRCol492 MemRCol523 1000.000000
R3524 MemRCol524 MemRCol556 1000.000000
R3557 MemRCol557 MemRCol590 1000.000000
R3591 MemRCol591 MemRCol625 1000.000000
R3626 MemRCol626 MemRCol661 1000.000000
R3662 MemRCol662 MemRCol698 1000.000000
R316 MemRCol16 MemRCol22 1000.000000
R323 MemRCol23 MemRCol30 1000.000000
R331 MemRCol31 MemRCol39 1000.000000
R340 MemRCol40 MemRCol49 1000.000000
R350 MemRCol50 MemRCol60 1000.000000
R361 MemRCol61 MemRCol72 1000.000000
R373 MemRCol73 MemRCol85 1000.000000
R386 MemRCol86 MemRCol99 1000.000000
R3100 MemRCol100 MemRCol114 1000.000000
R3115 MemRCol115 MemRCol130 1000.000000
R3131 MemRCol131 MemRCol147 1000.000000
R3148 MemRCol148 MemRCol165 1000.000000
R3166 MemRCol166 MemRCol184 1000.000000
R3185 MemRCol185 MemRCol204 1000.000000
R3205 MemRCol205 MemRCol225 1000.000000
R3226 MemRCol226 MemRCol247 1000.000000
R3248 MemRCol248 MemRCol270 1000.000000
R3271 MemRCol271 MemRCol294 1000.000000
R3295 MemRCol295 MemRCol319 1000.000000
R3320 MemRCol320 MemRCol345 1000.000000
R3346 MemRCol346 MemRCol372 1000.000000
R3373 MemRCol373 MemRCol400 1000.000000
R3401 MemRCol401 MemRCol429 1000.000000
R3430 MemRCol430 MemRCol459 1000.000000
R3460 MemRCol460 MemRCol490 1000.000000
R3491 MemRCol491 MemRCol522 1000.000000
R3523 MemRCol523 MemRCol555 1000.000000
R3556 MemRCol556 MemRCol589 1000.000000
R3590 MemRCol590 MemRCol624 1000.000000
R3625 MemRCol625 MemRCol660 1000.000000
R3661 MemRCol661 MemRCol697 1000.000000
R3698 MemRCol698 MemRCol735 1000.000000
R322 MemRCol22 MemRCol29 1000.000000
R330 MemRCol30 MemRCol38 1000.000000
R339 MemRCol39 MemRCol48 1000.000000
R349 MemRCol49 MemRCol59 1000.000000
R360 MemRCol60 MemRCol71 1000.000000
R372 MemRCol72 MemRCol84 1000.000000
R385 MemRCol85 MemRCol98 1000.000000
R399 MemRCol99 MemRCol113 1000.000000
R3114 MemRCol114 MemRCol129 1000.000000
R3130 MemRCol130 MemRCol146 1000.000000
R3147 MemRCol147 MemRCol164 1000.000000
R3165 MemRCol165 MemRCol183 1000.000000
R3184 MemRCol184 MemRCol203 1000.000000
R3204 MemRCol204 MemRCol224 1000.000000
R3225 MemRCol225 MemRCol246 1000.000000
R3247 MemRCol247 MemRCol269 1000.000000
R3270 MemRCol270 MemRCol293 1000.000000
R3294 MemRCol294 MemRCol318 1000.000000
R3319 MemRCol319 MemRCol344 1000.000000
R3345 MemRCol345 MemRCol371 1000.000000
R3372 MemRCol372 MemRCol399 1000.000000
R3400 MemRCol400 MemRCol428 1000.000000
R3429 MemRCol429 MemRCol458 1000.000000
R3459 MemRCol459 MemRCol489 1000.000000
R3490 MemRCol490 MemRCol521 1000.000000
R3522 MemRCol522 MemRCol554 1000.000000
R3555 MemRCol555 MemRCol588 1000.000000
R3589 MemRCol589 MemRCol623 1000.000000
R3624 MemRCol624 MemRCol659 1000.000000
R3660 MemRCol660 MemRCol696 1000.000000
R3697 MemRCol697 MemRCol734 1000.000000
R3735 MemRCol735 MemRCol773 1000.000000
R329 MemRCol29 MemRCol37 1000.000000
R338 MemRCol38 MemRCol47 1000.000000
R348 MemRCol48 MemRCol58 1000.000000
R359 MemRCol59 MemRCol70 1000.000000
R371 MemRCol71 MemRCol83 1000.000000
R384 MemRCol84 MemRCol97 1000.000000
R398 MemRCol98 MemRCol112 1000.000000
R3113 MemRCol113 MemRCol128 1000.000000
R3129 MemRCol129 MemRCol145 1000.000000
R3146 MemRCol146 MemRCol163 1000.000000
R3164 MemRCol164 MemRCol182 1000.000000
R3183 MemRCol183 MemRCol202 1000.000000
R3203 MemRCol203 MemRCol223 1000.000000
R3224 MemRCol224 MemRCol245 1000.000000
R3246 MemRCol246 MemRCol268 1000.000000
R3269 MemRCol269 MemRCol292 1000.000000
R3293 MemRCol293 MemRCol317 1000.000000
R3318 MemRCol318 MemRCol343 1000.000000
R3344 MemRCol344 MemRCol370 1000.000000
R3371 MemRCol371 MemRCol398 1000.000000
R3399 MemRCol399 MemRCol427 1000.000000
R3428 MemRCol428 MemRCol457 1000.000000
R3458 MemRCol458 MemRCol488 1000.000000
R3489 MemRCol489 MemRCol520 1000.000000
R3521 MemRCol521 MemRCol553 1000.000000
R3554 MemRCol554 MemRCol587 1000.000000
R3588 MemRCol588 MemRCol622 1000.000000
R3623 MemRCol623 MemRCol658 1000.000000
R3659 MemRCol659 MemRCol695 1000.000000
R3696 MemRCol696 MemRCol733 1000.000000
R3734 MemRCol734 MemRCol772 1000.000000
R3773 MemRCol773 MemRCol812 1000.000000
R337 MemRCol37 MemRCol46 1000.000000
R347 MemRCol47 MemRCol57 1000.000000
R358 MemRCol58 MemRCol69 1000.000000
R370 MemRCol70 MemRCol82 1000.000000
R383 MemRCol83 MemRCol96 1000.000000
R397 MemRCol97 MemRCol111 1000.000000
R3112 MemRCol112 MemRCol127 1000.000000
R3128 MemRCol128 MemRCol144 1000.000000
R3145 MemRCol145 MemRCol162 1000.000000
R3163 MemRCol163 MemRCol181 1000.000000
R3182 MemRCol182 MemRCol201 1000.000000
R3202 MemRCol202 MemRCol222 1000.000000
R3223 MemRCol223 MemRCol244 1000.000000
R3245 MemRCol245 MemRCol267 1000.000000
R3268 MemRCol268 MemRCol291 1000.000000
R3292 MemRCol292 MemRCol316 1000.000000
R3317 MemRCol317 MemRCol342 1000.000000
R3343 MemRCol343 MemRCol369 1000.000000
R3370 MemRCol370 MemRCol397 1000.000000
R3398 MemRCol398 MemRCol426 1000.000000
R3427 MemRCol427 MemRCol456 1000.000000
R3457 MemRCol457 MemRCol487 1000.000000
R3488 MemRCol488 MemRCol519 1000.000000
R3520 MemRCol520 MemRCol552 1000.000000
R3553 MemRCol553 MemRCol586 1000.000000
R3587 MemRCol587 MemRCol621 1000.000000
R3622 MemRCol622 MemRCol657 1000.000000
R3658 MemRCol658 MemRCol694 1000.000000
R3695 MemRCol695 MemRCol732 1000.000000
R3733 MemRCol733 MemRCol771 1000.000000
R3772 MemRCol772 MemRCol811 1000.000000
R3812 MemRCol812 MemRCol852 1000.000000
R346 MemRCol46 MemRCol56 1000.000000
R357 MemRCol57 MemRCol68 1000.000000
R369 MemRCol69 MemRCol81 1000.000000
R382 MemRCol82 MemRCol95 1000.000000
R396 MemRCol96 MemRCol110 1000.000000
R3111 MemRCol111 MemRCol126 1000.000000
R3127 MemRCol127 MemRCol143 1000.000000
R3144 MemRCol144 MemRCol161 1000.000000
R3162 MemRCol162 MemRCol180 1000.000000
R3181 MemRCol181 MemRCol200 1000.000000
R3201 MemRCol201 MemRCol221 1000.000000
R3222 MemRCol222 MemRCol243 1000.000000
R3244 MemRCol244 MemRCol266 1000.000000
R3267 MemRCol267 MemRCol290 1000.000000
R3291 MemRCol291 MemRCol315 1000.000000
R3316 MemRCol316 MemRCol341 1000.000000
R3342 MemRCol342 MemRCol368 1000.000000
R3369 MemRCol369 MemRCol396 1000.000000
R3397 MemRCol397 MemRCol425 1000.000000
R3426 MemRCol426 MemRCol455 1000.000000
R3456 MemRCol456 MemRCol486 1000.000000
R3487 MemRCol487 MemRCol518 1000.000000
R3519 MemRCol519 MemRCol551 1000.000000
R3552 MemRCol552 MemRCol585 1000.000000
R3586 MemRCol586 MemRCol620 1000.000000
R3621 MemRCol621 MemRCol656 1000.000000
R3657 MemRCol657 MemRCol693 1000.000000
R3694 MemRCol694 MemRCol731 1000.000000
R3732 MemRCol732 MemRCol770 1000.000000
R3771 MemRCol771 MemRCol810 1000.000000
R3811 MemRCol811 MemRCol851 1000.000000
R3852 MemRCol852 MemRCol893 1000.000000
R356 MemRCol56 MemRCol67 1000.000000
R368 MemRCol68 MemRCol80 1000.000000
R381 MemRCol81 MemRCol94 1000.000000
R395 MemRCol95 MemRCol109 1000.000000
R3110 MemRCol110 MemRCol125 1000.000000
R3126 MemRCol126 MemRCol142 1000.000000
R3143 MemRCol143 MemRCol160 1000.000000
R3161 MemRCol161 MemRCol179 1000.000000
R3180 MemRCol180 MemRCol199 1000.000000
R3200 MemRCol200 MemRCol220 1000.000000
R3221 MemRCol221 MemRCol242 1000.000000
R3243 MemRCol243 MemRCol265 1000.000000
R3266 MemRCol266 MemRCol289 1000.000000
R3290 MemRCol290 MemRCol314 1000.000000
R3315 MemRCol315 MemRCol340 1000.000000
R3341 MemRCol341 MemRCol367 1000.000000
R3368 MemRCol368 MemRCol395 1000.000000
R3396 MemRCol396 MemRCol424 1000.000000
R3425 MemRCol425 MemRCol454 1000.000000
R3455 MemRCol455 MemRCol485 1000.000000
R3486 MemRCol486 MemRCol517 1000.000000
R3518 MemRCol518 MemRCol550 1000.000000
R3551 MemRCol551 MemRCol584 1000.000000
R3585 MemRCol585 MemRCol619 1000.000000
R3620 MemRCol620 MemRCol655 1000.000000
R3656 MemRCol656 MemRCol692 1000.000000
R3693 MemRCol693 MemRCol730 1000.000000
R3731 MemRCol731 MemRCol769 1000.000000
R3770 MemRCol770 MemRCol809 1000.000000
R3810 MemRCol810 MemRCol850 1000.000000
R3851 MemRCol851 MemRCol892 1000.000000
R3893 MemRCol893 MemRCol935 1000.000000
R367 MemRCol67 MemRCol79 1000.000000
R380 MemRCol80 MemRCol93 1000.000000
R394 MemRCol94 MemRCol108 1000.000000
R3109 MemRCol109 MemRCol124 1000.000000
R3125 MemRCol125 MemRCol141 1000.000000
R3142 MemRCol142 MemRCol159 1000.000000
R3160 MemRCol160 MemRCol178 1000.000000
R3179 MemRCol179 MemRCol198 1000.000000
R3199 MemRCol199 MemRCol219 1000.000000
R3220 MemRCol220 MemRCol241 1000.000000
R3242 MemRCol242 MemRCol264 1000.000000
R3265 MemRCol265 MemRCol288 1000.000000
R3289 MemRCol289 MemRCol313 1000.000000
R3314 MemRCol314 MemRCol339 1000.000000
R3340 MemRCol340 MemRCol366 1000.000000
R3367 MemRCol367 MemRCol394 1000.000000
R3395 MemRCol395 MemRCol423 1000.000000
R3424 MemRCol424 MemRCol453 1000.000000
R3454 MemRCol454 MemRCol484 1000.000000
R3485 MemRCol485 MemRCol516 1000.000000
R3517 MemRCol517 MemRCol549 1000.000000
R3550 MemRCol550 MemRCol583 1000.000000
R3584 MemRCol584 MemRCol618 1000.000000
R3619 MemRCol619 MemRCol654 1000.000000
R3655 MemRCol655 MemRCol691 1000.000000
R3692 MemRCol692 MemRCol729 1000.000000
R3730 MemRCol730 MemRCol768 1000.000000
R3769 MemRCol769 MemRCol808 1000.000000
R3809 MemRCol809 MemRCol849 1000.000000
R3850 MemRCol850 MemRCol891 1000.000000
R3892 MemRCol892 MemRCol934 1000.000000
R3935 MemRCol935 MemRCol978 1000.000000
R379 MemRCol79 MemRCol92 1000.000000
R393 MemRCol93 MemRCol107 1000.000000
R3108 MemRCol108 MemRCol123 1000.000000
R3124 MemRCol124 MemRCol140 1000.000000
R3141 MemRCol141 MemRCol158 1000.000000
R3159 MemRCol159 MemRCol177 1000.000000
R3178 MemRCol178 MemRCol197 1000.000000
R3198 MemRCol198 MemRCol218 1000.000000
R3219 MemRCol219 MemRCol240 1000.000000
R3241 MemRCol241 MemRCol263 1000.000000
R3264 MemRCol264 MemRCol287 1000.000000
R3288 MemRCol288 MemRCol312 1000.000000
R3313 MemRCol313 MemRCol338 1000.000000
R3339 MemRCol339 MemRCol365 1000.000000
R3366 MemRCol366 MemRCol393 1000.000000
R3394 MemRCol394 MemRCol422 1000.000000
R3423 MemRCol423 MemRCol452 1000.000000
R3453 MemRCol453 MemRCol483 1000.000000
R3484 MemRCol484 MemRCol515 1000.000000
R3516 MemRCol516 MemRCol548 1000.000000
R3549 MemRCol549 MemRCol582 1000.000000
R3583 MemRCol583 MemRCol617 1000.000000
R3618 MemRCol618 MemRCol653 1000.000000
R3654 MemRCol654 MemRCol690 1000.000000
R3691 MemRCol691 MemRCol728 1000.000000
R3729 MemRCol729 MemRCol767 1000.000000
R3768 MemRCol768 MemRCol807 1000.000000
R3808 MemRCol808 MemRCol848 1000.000000
R3849 MemRCol849 MemRCol890 1000.000000
R3891 MemRCol891 MemRCol933 1000.000000
R3934 MemRCol934 MemRCol977 1000.000000
R3978 MemRCol978 MemRCol1022 1000.000000
R392 MemRCol92 MemRCol106 1000.000000
R3107 MemRCol107 MemRCol122 1000.000000
R3123 MemRCol123 MemRCol139 1000.000000
R3140 MemRCol140 MemRCol157 1000.000000
R3158 MemRCol158 MemRCol176 1000.000000
R3177 MemRCol177 MemRCol196 1000.000000
R3197 MemRCol197 MemRCol217 1000.000000
R3218 MemRCol218 MemRCol239 1000.000000
R3240 MemRCol240 MemRCol262 1000.000000
R3263 MemRCol263 MemRCol286 1000.000000
R3287 MemRCol287 MemRCol311 1000.000000
R3312 MemRCol312 MemRCol337 1000.000000
R3338 MemRCol338 MemRCol364 1000.000000
R3365 MemRCol365 MemRCol392 1000.000000
R3393 MemRCol393 MemRCol421 1000.000000
R3422 MemRCol422 MemRCol451 1000.000000
R3452 MemRCol452 MemRCol482 1000.000000
R3483 MemRCol483 MemRCol514 1000.000000
R3515 MemRCol515 MemRCol547 1000.000000
R3548 MemRCol548 MemRCol581 1000.000000
R3582 MemRCol582 MemRCol616 1000.000000
R3617 MemRCol617 MemRCol652 1000.000000
R3653 MemRCol653 MemRCol689 1000.000000
R3690 MemRCol690 MemRCol727 1000.000000
R3728 MemRCol728 MemRCol766 1000.000000
R3767 MemRCol767 MemRCol806 1000.000000
R3807 MemRCol807 MemRCol847 1000.000000
R3848 MemRCol848 MemRCol889 1000.000000
R3890 MemRCol890 MemRCol932 1000.000000
R3933 MemRCol933 MemRCol976 1000.000000
R3977 MemRCol977 MemRCol1021 1000.000000
R31022 MemRCol1022 MemRCol1067 1000.000000
R3106 MemRCol106 MemRCol121 1000.000000
R3122 MemRCol122 MemRCol138 1000.000000
R3139 MemRCol139 MemRCol156 1000.000000
R3157 MemRCol157 MemRCol175 1000.000000
R3176 MemRCol176 MemRCol195 1000.000000
R3196 MemRCol196 MemRCol216 1000.000000
R3217 MemRCol217 MemRCol238 1000.000000
R3239 MemRCol239 MemRCol261 1000.000000
R3262 MemRCol262 MemRCol285 1000.000000
R3286 MemRCol286 MemRCol310 1000.000000
R3311 MemRCol311 MemRCol336 1000.000000
R3337 MemRCol337 MemRCol363 1000.000000
R3364 MemRCol364 MemRCol391 1000.000000
R3392 MemRCol392 MemRCol420 1000.000000
R3421 MemRCol421 MemRCol450 1000.000000
R3451 MemRCol451 MemRCol481 1000.000000
R3482 MemRCol482 MemRCol513 1000.000000
R3514 MemRCol514 MemRCol546 1000.000000
R3547 MemRCol547 MemRCol580 1000.000000
R3581 MemRCol581 MemRCol615 1000.000000
R3616 MemRCol616 MemRCol651 1000.000000
R3652 MemRCol652 MemRCol688 1000.000000
R3689 MemRCol689 MemRCol726 1000.000000
R3727 MemRCol727 MemRCol765 1000.000000
R3766 MemRCol766 MemRCol805 1000.000000
R3806 MemRCol806 MemRCol846 1000.000000
R3847 MemRCol847 MemRCol888 1000.000000
R3889 MemRCol889 MemRCol931 1000.000000
R3932 MemRCol932 MemRCol975 1000.000000
R3976 MemRCol976 MemRCol1020 1000.000000
R31021 MemRCol1021 MemRCol1066 1000.000000
R31067 MemRCol1067 MemRCol1113 1000.000000
R3121 MemRCol121 MemRCol137 1000.000000
R3138 MemRCol138 MemRCol155 1000.000000
R3156 MemRCol156 MemRCol174 1000.000000
R3175 MemRCol175 MemRCol194 1000.000000
R3195 MemRCol195 MemRCol215 1000.000000
R3216 MemRCol216 MemRCol237 1000.000000
R3238 MemRCol238 MemRCol260 1000.000000
R3261 MemRCol261 MemRCol284 1000.000000
R3285 MemRCol285 MemRCol309 1000.000000
R3310 MemRCol310 MemRCol335 1000.000000
R3336 MemRCol336 MemRCol362 1000.000000
R3363 MemRCol363 MemRCol390 1000.000000
R3391 MemRCol391 MemRCol419 1000.000000
R3420 MemRCol420 MemRCol449 1000.000000
R3450 MemRCol450 MemRCol480 1000.000000
R3481 MemRCol481 MemRCol512 1000.000000
R3513 MemRCol513 MemRCol545 1000.000000
R3546 MemRCol546 MemRCol579 1000.000000
R3580 MemRCol580 MemRCol614 1000.000000
R3615 MemRCol615 MemRCol650 1000.000000
R3651 MemRCol651 MemRCol687 1000.000000
R3688 MemRCol688 MemRCol725 1000.000000
R3726 MemRCol726 MemRCol764 1000.000000
R3765 MemRCol765 MemRCol804 1000.000000
R3805 MemRCol805 MemRCol845 1000.000000
R3846 MemRCol846 MemRCol887 1000.000000
R3888 MemRCol888 MemRCol930 1000.000000
R3931 MemRCol931 MemRCol974 1000.000000
R3975 MemRCol975 MemRCol1019 1000.000000
R31020 MemRCol1020 MemRCol1065 1000.000000
R31066 MemRCol1066 MemRCol1112 1000.000000
R31113 MemRCol1113 MemRCol1160 1000.000000
R3137 MemRCol137 MemRCol154 1000.000000
R3155 MemRCol155 MemRCol173 1000.000000
R3174 MemRCol174 MemRCol193 1000.000000
R3194 MemRCol194 MemRCol214 1000.000000
R3215 MemRCol215 MemRCol236 1000.000000
R3237 MemRCol237 MemRCol259 1000.000000
R3260 MemRCol260 MemRCol283 1000.000000
R3284 MemRCol284 MemRCol308 1000.000000
R3309 MemRCol309 MemRCol334 1000.000000
R3335 MemRCol335 MemRCol361 1000.000000
R3362 MemRCol362 MemRCol389 1000.000000
R3390 MemRCol390 MemRCol418 1000.000000
R3419 MemRCol419 MemRCol448 1000.000000
R3449 MemRCol449 MemRCol479 1000.000000
R3480 MemRCol480 MemRCol511 1000.000000
R3512 MemRCol512 MemRCol544 1000.000000
R3545 MemRCol545 MemRCol578 1000.000000
R3579 MemRCol579 MemRCol613 1000.000000
R3614 MemRCol614 MemRCol649 1000.000000
R3650 MemRCol650 MemRCol686 1000.000000
R3687 MemRCol687 MemRCol724 1000.000000
R3725 MemRCol725 MemRCol763 1000.000000
R3764 MemRCol764 MemRCol803 1000.000000
R3804 MemRCol804 MemRCol844 1000.000000
R3845 MemRCol845 MemRCol886 1000.000000
R3887 MemRCol887 MemRCol929 1000.000000
R3930 MemRCol930 MemRCol973 1000.000000
R3974 MemRCol974 MemRCol1018 1000.000000
R31019 MemRCol1019 MemRCol1064 1000.000000
R31065 MemRCol1065 MemRCol1111 1000.000000
R31112 MemRCol1112 MemRCol1159 1000.000000
R31160 MemRCol1160 MemRCol1208 1000.000000
R3154 MemRCol154 MemRCol172 1000.000000
R3173 MemRCol173 MemRCol192 1000.000000
R3193 MemRCol193 MemRCol213 1000.000000
R3214 MemRCol214 MemRCol235 1000.000000
R3236 MemRCol236 MemRCol258 1000.000000
R3259 MemRCol259 MemRCol282 1000.000000
R3283 MemRCol283 MemRCol307 1000.000000
R3308 MemRCol308 MemRCol333 1000.000000
R3334 MemRCol334 MemRCol360 1000.000000
R3361 MemRCol361 MemRCol388 1000.000000
R3389 MemRCol389 MemRCol417 1000.000000
R3418 MemRCol418 MemRCol447 1000.000000
R3448 MemRCol448 MemRCol478 1000.000000
R3479 MemRCol479 MemRCol510 1000.000000
R3511 MemRCol511 MemRCol543 1000.000000
R3544 MemRCol544 MemRCol577 1000.000000
R3578 MemRCol578 MemRCol612 1000.000000
R3613 MemRCol613 MemRCol648 1000.000000
R3649 MemRCol649 MemRCol685 1000.000000
R3686 MemRCol686 MemRCol723 1000.000000
R3724 MemRCol724 MemRCol762 1000.000000
R3763 MemRCol763 MemRCol802 1000.000000
R3803 MemRCol803 MemRCol843 1000.000000
R3844 MemRCol844 MemRCol885 1000.000000
R3886 MemRCol886 MemRCol928 1000.000000
R3929 MemRCol929 MemRCol972 1000.000000
R3973 MemRCol973 MemRCol1017 1000.000000
R31018 MemRCol1018 MemRCol1063 1000.000000
R31064 MemRCol1064 MemRCol1110 1000.000000
R31111 MemRCol1111 MemRCol1158 1000.000000
R31159 MemRCol1159 MemRCol1207 1000.000000
R31208 MemRCol1208 MemRCol1257 1000.000000
R3172 MemRCol172 MemRCol191 1000.000000
R3192 MemRCol192 MemRCol212 1000.000000
R3213 MemRCol213 MemRCol234 1000.000000
R3235 MemRCol235 MemRCol257 1000.000000
R3258 MemRCol258 MemRCol281 1000.000000
R3282 MemRCol282 MemRCol306 1000.000000
R3307 MemRCol307 MemRCol332 1000.000000
R3333 MemRCol333 MemRCol359 1000.000000
R3360 MemRCol360 MemRCol387 1000.000000
R3388 MemRCol388 MemRCol416 1000.000000
R3417 MemRCol417 MemRCol446 1000.000000
R3447 MemRCol447 MemRCol477 1000.000000
R3478 MemRCol478 MemRCol509 1000.000000
R3510 MemRCol510 MemRCol542 1000.000000
R3543 MemRCol543 MemRCol576 1000.000000
R3577 MemRCol577 MemRCol611 1000.000000
R3612 MemRCol612 MemRCol647 1000.000000
R3648 MemRCol648 MemRCol684 1000.000000
R3685 MemRCol685 MemRCol722 1000.000000
R3723 MemRCol723 MemRCol761 1000.000000
R3762 MemRCol762 MemRCol801 1000.000000
R3802 MemRCol802 MemRCol842 1000.000000
R3843 MemRCol843 MemRCol884 1000.000000
R3885 MemRCol885 MemRCol927 1000.000000
R3928 MemRCol928 MemRCol971 1000.000000
R3972 MemRCol972 MemRCol1016 1000.000000
R31017 MemRCol1017 MemRCol1062 1000.000000
R31063 MemRCol1063 MemRCol1109 1000.000000
R31110 MemRCol1110 MemRCol1157 1000.000000
R31158 MemRCol1158 MemRCol1206 1000.000000
R31207 MemRCol1207 MemRCol1256 1000.000000
R31257 MemRCol1257 MemRCol1307 1000.000000
R3191 MemRCol191 MemRCol211 1000.000000
R3212 MemRCol212 MemRCol233 1000.000000
R3234 MemRCol234 MemRCol256 1000.000000
R3257 MemRCol257 MemRCol280 1000.000000
R3281 MemRCol281 MemRCol305 1000.000000
R3306 MemRCol306 MemRCol331 1000.000000
R3332 MemRCol332 MemRCol358 1000.000000
R3359 MemRCol359 MemRCol386 1000.000000
R3387 MemRCol387 MemRCol415 1000.000000
R3416 MemRCol416 MemRCol445 1000.000000
R3446 MemRCol446 MemRCol476 1000.000000
R3477 MemRCol477 MemRCol508 1000.000000
R3509 MemRCol509 MemRCol541 1000.000000
R3542 MemRCol542 MemRCol575 1000.000000
R3576 MemRCol576 MemRCol610 1000.000000
R3611 MemRCol611 MemRCol646 1000.000000
R3647 MemRCol647 MemRCol683 1000.000000
R3684 MemRCol684 MemRCol721 1000.000000
R3722 MemRCol722 MemRCol760 1000.000000
R3761 MemRCol761 MemRCol800 1000.000000
R3801 MemRCol801 MemRCol841 1000.000000
R3842 MemRCol842 MemRCol883 1000.000000
R3884 MemRCol884 MemRCol926 1000.000000
R3927 MemRCol927 MemRCol970 1000.000000
R3971 MemRCol971 MemRCol1015 1000.000000
R31016 MemRCol1016 MemRCol1061 1000.000000
R31062 MemRCol1062 MemRCol1108 1000.000000
R31109 MemRCol1109 MemRCol1156 1000.000000
R31157 MemRCol1157 MemRCol1205 1000.000000
R31206 MemRCol1206 MemRCol1255 1000.000000
R31256 MemRCol1256 MemRCol1306 1000.000000
R31307 MemRCol1307 MemRCol1358 1000.000000
R3211 MemRCol211 MemRCol232 1000.000000
R3233 MemRCol233 MemRCol255 1000.000000
R3256 MemRCol256 MemRCol279 1000.000000
R3280 MemRCol280 MemRCol304 1000.000000
R3305 MemRCol305 MemRCol330 1000.000000
R3331 MemRCol331 MemRCol357 1000.000000
R3358 MemRCol358 MemRCol385 1000.000000
R3386 MemRCol386 MemRCol414 1000.000000
R3415 MemRCol415 MemRCol444 1000.000000
R3445 MemRCol445 MemRCol475 1000.000000
R3476 MemRCol476 MemRCol507 1000.000000
R3508 MemRCol508 MemRCol540 1000.000000
R3541 MemRCol541 MemRCol574 1000.000000
R3575 MemRCol575 MemRCol609 1000.000000
R3610 MemRCol610 MemRCol645 1000.000000
R3646 MemRCol646 MemRCol682 1000.000000
R3683 MemRCol683 MemRCol720 1000.000000
R3721 MemRCol721 MemRCol759 1000.000000
R3760 MemRCol760 MemRCol799 1000.000000
R3800 MemRCol800 MemRCol840 1000.000000
R3841 MemRCol841 MemRCol882 1000.000000
R3883 MemRCol883 MemRCol925 1000.000000
R3926 MemRCol926 MemRCol969 1000.000000
R3970 MemRCol970 MemRCol1014 1000.000000
R31015 MemRCol1015 MemRCol1060 1000.000000
R31061 MemRCol1061 MemRCol1107 1000.000000
R31108 MemRCol1108 MemRCol1155 1000.000000
R31156 MemRCol1156 MemRCol1204 1000.000000
R31205 MemRCol1205 MemRCol1254 1000.000000
R31255 MemRCol1255 MemRCol1305 1000.000000
R31306 MemRCol1306 MemRCol1357 1000.000000
R31358 MemRCol1358 MemRCol1410 1000.000000
R3232 MemRCol232 MemRCol254 1000.000000
R3255 MemRCol255 MemRCol278 1000.000000
R3279 MemRCol279 MemRCol303 1000.000000
R3304 MemRCol304 MemRCol329 1000.000000
R3330 MemRCol330 MemRCol356 1000.000000
R3357 MemRCol357 MemRCol384 1000.000000
R3385 MemRCol385 MemRCol413 1000.000000
R3414 MemRCol414 MemRCol443 1000.000000
R3444 MemRCol444 MemRCol474 1000.000000
R3475 MemRCol475 MemRCol506 1000.000000
R3507 MemRCol507 MemRCol539 1000.000000
R3540 MemRCol540 MemRCol573 1000.000000
R3574 MemRCol574 MemRCol608 1000.000000
R3609 MemRCol609 MemRCol644 1000.000000
R3645 MemRCol645 MemRCol681 1000.000000
R3682 MemRCol682 MemRCol719 1000.000000
R3720 MemRCol720 MemRCol758 1000.000000
R3759 MemRCol759 MemRCol798 1000.000000
R3799 MemRCol799 MemRCol839 1000.000000
R3840 MemRCol840 MemRCol881 1000.000000
R3882 MemRCol882 MemRCol924 1000.000000
R3925 MemRCol925 MemRCol968 1000.000000
R3969 MemRCol969 MemRCol1013 1000.000000
R31014 MemRCol1014 MemRCol1059 1000.000000
R31060 MemRCol1060 MemRCol1106 1000.000000
R31107 MemRCol1107 MemRCol1154 1000.000000
R31155 MemRCol1155 MemRCol1203 1000.000000
R31204 MemRCol1204 MemRCol1253 1000.000000
R31254 MemRCol1254 MemRCol1304 1000.000000
R31305 MemRCol1305 MemRCol1356 1000.000000
R31357 MemRCol1357 MemRCol1409 1000.000000
R31410 MemRCol1410 MemRCol1463 1000.000000
R3254 MemRCol254 MemRCol277 1000.000000
R3278 MemRCol278 MemRCol302 1000.000000
R3303 MemRCol303 MemRCol328 1000.000000
R3329 MemRCol329 MemRCol355 1000.000000
R3356 MemRCol356 MemRCol383 1000.000000
R3384 MemRCol384 MemRCol412 1000.000000
R3413 MemRCol413 MemRCol442 1000.000000
R3443 MemRCol443 MemRCol473 1000.000000
R3474 MemRCol474 MemRCol505 1000.000000
R3506 MemRCol506 MemRCol538 1000.000000
R3539 MemRCol539 MemRCol572 1000.000000
R3573 MemRCol573 MemRCol607 1000.000000
R3608 MemRCol608 MemRCol643 1000.000000
R3644 MemRCol644 MemRCol680 1000.000000
R3681 MemRCol681 MemRCol718 1000.000000
R3719 MemRCol719 MemRCol757 1000.000000
R3758 MemRCol758 MemRCol797 1000.000000
R3798 MemRCol798 MemRCol838 1000.000000
R3839 MemRCol839 MemRCol880 1000.000000
R3881 MemRCol881 MemRCol923 1000.000000
R3924 MemRCol924 MemRCol967 1000.000000
R3968 MemRCol968 MemRCol1012 1000.000000
R31013 MemRCol1013 MemRCol1058 1000.000000
R31059 MemRCol1059 MemRCol1105 1000.000000
R31106 MemRCol1106 MemRCol1153 1000.000000
R31154 MemRCol1154 MemRCol1202 1000.000000
R31203 MemRCol1203 MemRCol1252 1000.000000
R31253 MemRCol1253 MemRCol1303 1000.000000
R31304 MemRCol1304 MemRCol1355 1000.000000
R31356 MemRCol1356 MemRCol1408 1000.000000
R31409 MemRCol1409 MemRCol1462 1000.000000
R31463 MemRCol1463 MemRCol1517 1000.000000
R3277 MemRCol277 MemRCol301 1000.000000
R3302 MemRCol302 MemRCol327 1000.000000
R3328 MemRCol328 MemRCol354 1000.000000
R3355 MemRCol355 MemRCol382 1000.000000
R3383 MemRCol383 MemRCol411 1000.000000
R3412 MemRCol412 MemRCol441 1000.000000
R3442 MemRCol442 MemRCol472 1000.000000
R3473 MemRCol473 MemRCol504 1000.000000
R3505 MemRCol505 MemRCol537 1000.000000
R3538 MemRCol538 MemRCol571 1000.000000
R3572 MemRCol572 MemRCol606 1000.000000
R3607 MemRCol607 MemRCol642 1000.000000
R3643 MemRCol643 MemRCol679 1000.000000
R3680 MemRCol680 MemRCol717 1000.000000
R3718 MemRCol718 MemRCol756 1000.000000
R3757 MemRCol757 MemRCol796 1000.000000
R3797 MemRCol797 MemRCol837 1000.000000
R3838 MemRCol838 MemRCol879 1000.000000
R3880 MemRCol880 MemRCol922 1000.000000
R3923 MemRCol923 MemRCol966 1000.000000
R3967 MemRCol967 MemRCol1011 1000.000000
R31012 MemRCol1012 MemRCol1057 1000.000000
R31058 MemRCol1058 MemRCol1104 1000.000000
R31105 MemRCol1105 MemRCol1152 1000.000000
R31153 MemRCol1153 MemRCol1201 1000.000000
R31202 MemRCol1202 MemRCol1251 1000.000000
R31252 MemRCol1252 MemRCol1302 1000.000000
R31303 MemRCol1303 MemRCol1354 1000.000000
R31355 MemRCol1355 MemRCol1407 1000.000000
R31408 MemRCol1408 MemRCol1461 1000.000000
R31462 MemRCol1462 MemRCol1516 1000.000000
R31517 MemRCol1517 MemRCol1572 1000.000000
R3301 MemRCol301 MemRCol326 1000.000000
R3327 MemRCol327 MemRCol353 1000.000000
R3354 MemRCol354 MemRCol381 1000.000000
R3382 MemRCol382 MemRCol410 1000.000000
R3411 MemRCol411 MemRCol440 1000.000000
R3441 MemRCol441 MemRCol471 1000.000000
R3472 MemRCol472 MemRCol503 1000.000000
R3504 MemRCol504 MemRCol536 1000.000000
R3537 MemRCol537 MemRCol570 1000.000000
R3571 MemRCol571 MemRCol605 1000.000000
R3606 MemRCol606 MemRCol641 1000.000000
R3642 MemRCol642 MemRCol678 1000.000000
R3679 MemRCol679 MemRCol716 1000.000000
R3717 MemRCol717 MemRCol755 1000.000000
R3756 MemRCol756 MemRCol795 1000.000000
R3796 MemRCol796 MemRCol836 1000.000000
R3837 MemRCol837 MemRCol878 1000.000000
R3879 MemRCol879 MemRCol921 1000.000000
R3922 MemRCol922 MemRCol965 1000.000000
R3966 MemRCol966 MemRCol1010 1000.000000
R31011 MemRCol1011 MemRCol1056 1000.000000
R31057 MemRCol1057 MemRCol1103 1000.000000
R31104 MemRCol1104 MemRCol1151 1000.000000
R31152 MemRCol1152 MemRCol1200 1000.000000
R31201 MemRCol1201 MemRCol1250 1000.000000
R31251 MemRCol1251 MemRCol1301 1000.000000
R31302 MemRCol1302 MemRCol1353 1000.000000
R31354 MemRCol1354 MemRCol1406 1000.000000
R31407 MemRCol1407 MemRCol1460 1000.000000
R31461 MemRCol1461 MemRCol1515 1000.000000
R31516 MemRCol1516 MemRCol1571 1000.000000
R31572 MemRCol1572 MemRCol1628 1000.000000
R3326 MemRCol326 MemRCol352 1000.000000
R3353 MemRCol353 MemRCol380 1000.000000
R3381 MemRCol381 MemRCol409 1000.000000
R3410 MemRCol410 MemRCol439 1000.000000
R3440 MemRCol440 MemRCol470 1000.000000
R3471 MemRCol471 MemRCol502 1000.000000
R3503 MemRCol503 MemRCol535 1000.000000
R3536 MemRCol536 MemRCol569 1000.000000
R3570 MemRCol570 MemRCol604 1000.000000
R3605 MemRCol605 MemRCol640 1000.000000
R3641 MemRCol641 MemRCol677 1000.000000
R3678 MemRCol678 MemRCol715 1000.000000
R3716 MemRCol716 MemRCol754 1000.000000
R3755 MemRCol755 MemRCol794 1000.000000
R3795 MemRCol795 MemRCol835 1000.000000
R3836 MemRCol836 MemRCol877 1000.000000
R3878 MemRCol878 MemRCol920 1000.000000
R3921 MemRCol921 MemRCol964 1000.000000
R3965 MemRCol965 MemRCol1009 1000.000000
R31010 MemRCol1010 MemRCol1055 1000.000000
R31056 MemRCol1056 MemRCol1102 1000.000000
R31103 MemRCol1103 MemRCol1150 1000.000000
R31151 MemRCol1151 MemRCol1199 1000.000000
R31200 MemRCol1200 MemRCol1249 1000.000000
R31250 MemRCol1250 MemRCol1300 1000.000000
R31301 MemRCol1301 MemRCol1352 1000.000000
R31353 MemRCol1353 MemRCol1405 1000.000000
R31406 MemRCol1406 MemRCol1459 1000.000000
R31460 MemRCol1460 MemRCol1514 1000.000000
R31515 MemRCol1515 MemRCol1570 1000.000000
R31571 MemRCol1571 MemRCol1627 1000.000000
R31628 MemRCol1628 MemRCol1685 1000.000000
R3352 MemRCol352 MemRCol379 1000.000000
R3380 MemRCol380 MemRCol408 1000.000000
R3409 MemRCol409 MemRCol438 1000.000000
R3439 MemRCol439 MemRCol469 1000.000000
R3470 MemRCol470 MemRCol501 1000.000000
R3502 MemRCol502 MemRCol534 1000.000000
R3535 MemRCol535 MemRCol568 1000.000000
R3569 MemRCol569 MemRCol603 1000.000000
R3604 MemRCol604 MemRCol639 1000.000000
R3640 MemRCol640 MemRCol676 1000.000000
R3677 MemRCol677 MemRCol714 1000.000000
R3715 MemRCol715 MemRCol753 1000.000000
R3754 MemRCol754 MemRCol793 1000.000000
R3794 MemRCol794 MemRCol834 1000.000000
R3835 MemRCol835 MemRCol876 1000.000000
R3877 MemRCol877 MemRCol919 1000.000000
R3920 MemRCol920 MemRCol963 1000.000000
R3964 MemRCol964 MemRCol1008 1000.000000
R31009 MemRCol1009 MemRCol1054 1000.000000
R31055 MemRCol1055 MemRCol1101 1000.000000
R31102 MemRCol1102 MemRCol1149 1000.000000
R31150 MemRCol1150 MemRCol1198 1000.000000
R31199 MemRCol1199 MemRCol1248 1000.000000
R31249 MemRCol1249 MemRCol1299 1000.000000
R31300 MemRCol1300 MemRCol1351 1000.000000
R31352 MemRCol1352 MemRCol1404 1000.000000
R31405 MemRCol1405 MemRCol1458 1000.000000
R31459 MemRCol1459 MemRCol1513 1000.000000
R31514 MemRCol1514 MemRCol1569 1000.000000
R31570 MemRCol1570 MemRCol1626 1000.000000
R31627 MemRCol1627 MemRCol1684 1000.000000
R31685 MemRCol1685 MemRCol1743 1000.000000
R3379 MemRCol379 MemRCol407 1000.000000
R3408 MemRCol408 MemRCol437 1000.000000
R3438 MemRCol438 MemRCol468 1000.000000
R3469 MemRCol469 MemRCol500 1000.000000
R3501 MemRCol501 MemRCol533 1000.000000
R3534 MemRCol534 MemRCol567 1000.000000
R3568 MemRCol568 MemRCol602 1000.000000
R3603 MemRCol603 MemRCol638 1000.000000
R3639 MemRCol639 MemRCol675 1000.000000
R3676 MemRCol676 MemRCol713 1000.000000
R3714 MemRCol714 MemRCol752 1000.000000
R3753 MemRCol753 MemRCol792 1000.000000
R3793 MemRCol793 MemRCol833 1000.000000
R3834 MemRCol834 MemRCol875 1000.000000
R3876 MemRCol876 MemRCol918 1000.000000
R3919 MemRCol919 MemRCol962 1000.000000
R3963 MemRCol963 MemRCol1007 1000.000000
R31008 MemRCol1008 MemRCol1053 1000.000000
R31054 MemRCol1054 MemRCol1100 1000.000000
R31101 MemRCol1101 MemRCol1148 1000.000000
R31149 MemRCol1149 MemRCol1197 1000.000000
R31198 MemRCol1198 MemRCol1247 1000.000000
R31248 MemRCol1248 MemRCol1298 1000.000000
R31299 MemRCol1299 MemRCol1350 1000.000000
R31351 MemRCol1351 MemRCol1403 1000.000000
R31404 MemRCol1404 MemRCol1457 1000.000000
R31458 MemRCol1458 MemRCol1512 1000.000000
R31513 MemRCol1513 MemRCol1568 1000.000000
R31569 MemRCol1569 MemRCol1625 1000.000000
R31626 MemRCol1626 MemRCol1683 1000.000000
R31684 MemRCol1684 MemRCol1742 1000.000000
R31743 MemRCol1743 MemRCol1802 1000.000000
R3407 MemRCol407 MemRCol436 1000.000000
R3437 MemRCol437 MemRCol467 1000.000000
R3468 MemRCol468 MemRCol499 1000.000000
R3500 MemRCol500 MemRCol532 1000.000000
R3533 MemRCol533 MemRCol566 1000.000000
R3567 MemRCol567 MemRCol601 1000.000000
R3602 MemRCol602 MemRCol637 1000.000000
R3638 MemRCol638 MemRCol674 1000.000000
R3675 MemRCol675 MemRCol712 1000.000000
R3713 MemRCol713 MemRCol751 1000.000000
R3752 MemRCol752 MemRCol791 1000.000000
R3792 MemRCol792 MemRCol832 1000.000000
R3833 MemRCol833 MemRCol874 1000.000000
R3875 MemRCol875 MemRCol917 1000.000000
R3918 MemRCol918 MemRCol961 1000.000000
R3962 MemRCol962 MemRCol1006 1000.000000
R31007 MemRCol1007 MemRCol1052 1000.000000
R31053 MemRCol1053 MemRCol1099 1000.000000
R31100 MemRCol1100 MemRCol1147 1000.000000
R31148 MemRCol1148 MemRCol1196 1000.000000
R31197 MemRCol1197 MemRCol1246 1000.000000
R31247 MemRCol1247 MemRCol1297 1000.000000
R31298 MemRCol1298 MemRCol1349 1000.000000
R31350 MemRCol1350 MemRCol1402 1000.000000
R31403 MemRCol1403 MemRCol1456 1000.000000
R31457 MemRCol1457 MemRCol1511 1000.000000
R31512 MemRCol1512 MemRCol1567 1000.000000
R31568 MemRCol1568 MemRCol1624 1000.000000
R31625 MemRCol1625 MemRCol1682 1000.000000
R31683 MemRCol1683 MemRCol1741 1000.000000
R31742 MemRCol1742 MemRCol1801 1000.000000
R31802 MemRCol1802 MemRCol1862 1000.000000
R3436 MemRCol436 MemRCol466 1000.000000
R3467 MemRCol467 MemRCol498 1000.000000
R3499 MemRCol499 MemRCol531 1000.000000
R3532 MemRCol532 MemRCol565 1000.000000
R3566 MemRCol566 MemRCol600 1000.000000
R3601 MemRCol601 MemRCol636 1000.000000
R3637 MemRCol637 MemRCol673 1000.000000
R3674 MemRCol674 MemRCol711 1000.000000
R3712 MemRCol712 MemRCol750 1000.000000
R3751 MemRCol751 MemRCol790 1000.000000
R3791 MemRCol791 MemRCol831 1000.000000
R3832 MemRCol832 MemRCol873 1000.000000
R3874 MemRCol874 MemRCol916 1000.000000
R3917 MemRCol917 MemRCol960 1000.000000
R3961 MemRCol961 MemRCol1005 1000.000000
R31006 MemRCol1006 MemRCol1051 1000.000000
R31052 MemRCol1052 MemRCol1098 1000.000000
R31099 MemRCol1099 MemRCol1146 1000.000000
R31147 MemRCol1147 MemRCol1195 1000.000000
R31196 MemRCol1196 MemRCol1245 1000.000000
R31246 MemRCol1246 MemRCol1296 1000.000000
R31297 MemRCol1297 MemRCol1348 1000.000000
R31349 MemRCol1349 MemRCol1401 1000.000000
R31402 MemRCol1402 MemRCol1455 1000.000000
R31456 MemRCol1456 MemRCol1510 1000.000000
R31511 MemRCol1511 MemRCol1566 1000.000000
R31567 MemRCol1567 MemRCol1623 1000.000000
R31624 MemRCol1624 MemRCol1681 1000.000000
R31682 MemRCol1682 MemRCol1740 1000.000000
R31741 MemRCol1741 MemRCol1800 1000.000000
R31801 MemRCol1801 MemRCol1861 1000.000000
R31862 MemRCol1862 MemRCol1923 1000.000000
R3466 MemRCol466 MemRCol497 1000.000000
R3498 MemRCol498 MemRCol530 1000.000000
R3531 MemRCol531 MemRCol564 1000.000000
R3565 MemRCol565 MemRCol599 1000.000000
R3600 MemRCol600 MemRCol635 1000.000000
R3636 MemRCol636 MemRCol672 1000.000000
R3673 MemRCol673 MemRCol710 1000.000000
R3711 MemRCol711 MemRCol749 1000.000000
R3750 MemRCol750 MemRCol789 1000.000000
R3790 MemRCol790 MemRCol830 1000.000000
R3831 MemRCol831 MemRCol872 1000.000000
R3873 MemRCol873 MemRCol915 1000.000000
R3916 MemRCol916 MemRCol959 1000.000000
R3960 MemRCol960 MemRCol1004 1000.000000
R31005 MemRCol1005 MemRCol1050 1000.000000
R31051 MemRCol1051 MemRCol1097 1000.000000
R31098 MemRCol1098 MemRCol1145 1000.000000
R31146 MemRCol1146 MemRCol1194 1000.000000
R31195 MemRCol1195 MemRCol1244 1000.000000
R31245 MemRCol1245 MemRCol1295 1000.000000
R31296 MemRCol1296 MemRCol1347 1000.000000
R31348 MemRCol1348 MemRCol1400 1000.000000
R31401 MemRCol1401 MemRCol1454 1000.000000
R31455 MemRCol1455 MemRCol1509 1000.000000
R31510 MemRCol1510 MemRCol1565 1000.000000
R31566 MemRCol1566 MemRCol1622 1000.000000
R31623 MemRCol1623 MemRCol1680 1000.000000
R31681 MemRCol1681 MemRCol1739 1000.000000
R31740 MemRCol1740 MemRCol1799 1000.000000
R31800 MemRCol1800 MemRCol1860 1000.000000
R31861 MemRCol1861 MemRCol1922 1000.000000
R31923 MemRCol1923 MemRCol1985 1000.000000
R3497 MemRCol497 MemRCol529 1000.000000
R3530 MemRCol530 MemRCol563 1000.000000
R3564 MemRCol564 MemRCol598 1000.000000
R3599 MemRCol599 MemRCol634 1000.000000
R3635 MemRCol635 MemRCol671 1000.000000
R3672 MemRCol672 MemRCol709 1000.000000
R3710 MemRCol710 MemRCol748 1000.000000
R3749 MemRCol749 MemRCol788 1000.000000
R3789 MemRCol789 MemRCol829 1000.000000
R3830 MemRCol830 MemRCol871 1000.000000
R3872 MemRCol872 MemRCol914 1000.000000
R3915 MemRCol915 MemRCol958 1000.000000
R3959 MemRCol959 MemRCol1003 1000.000000
R31004 MemRCol1004 MemRCol1049 1000.000000
R31050 MemRCol1050 MemRCol1096 1000.000000
R31097 MemRCol1097 MemRCol1144 1000.000000
R31145 MemRCol1145 MemRCol1193 1000.000000
R31194 MemRCol1194 MemRCol1243 1000.000000
R31244 MemRCol1244 MemRCol1294 1000.000000
R31295 MemRCol1295 MemRCol1346 1000.000000
R31347 MemRCol1347 MemRCol1399 1000.000000
R31400 MemRCol1400 MemRCol1453 1000.000000
R31454 MemRCol1454 MemRCol1508 1000.000000
R31509 MemRCol1509 MemRCol1564 1000.000000
R31565 MemRCol1565 MemRCol1621 1000.000000
R31622 MemRCol1622 MemRCol1679 1000.000000
R31680 MemRCol1680 MemRCol1738 1000.000000
R31739 MemRCol1739 MemRCol1798 1000.000000
R31799 MemRCol1799 MemRCol1859 1000.000000
R31860 MemRCol1860 MemRCol1921 1000.000000
R31922 MemRCol1922 MemRCol1984 1000.000000
R31985 MemRCol1985 MemRCol2048 1000.000000
R3529 MemRCol529 MemRCol562 1000.000000
R3563 MemRCol563 MemRCol597 1000.000000
R3598 MemRCol598 MemRCol633 1000.000000
R3634 MemRCol634 MemRCol670 1000.000000
R3671 MemRCol671 MemRCol708 1000.000000
R3709 MemRCol709 MemRCol747 1000.000000
R3748 MemRCol748 MemRCol787 1000.000000
R3788 MemRCol788 MemRCol828 1000.000000
R3829 MemRCol829 MemRCol870 1000.000000
R3871 MemRCol871 MemRCol913 1000.000000
R3914 MemRCol914 MemRCol957 1000.000000
R3958 MemRCol958 MemRCol1002 1000.000000
R31003 MemRCol1003 MemRCol1048 1000.000000
R31049 MemRCol1049 MemRCol1095 1000.000000
R31096 MemRCol1096 MemRCol1143 1000.000000
R31144 MemRCol1144 MemRCol1192 1000.000000
R31193 MemRCol1193 MemRCol1242 1000.000000
R31243 MemRCol1243 MemRCol1293 1000.000000
R31294 MemRCol1294 MemRCol1345 1000.000000
R31346 MemRCol1346 MemRCol1398 1000.000000
R31399 MemRCol1399 MemRCol1452 1000.000000
R31453 MemRCol1453 MemRCol1507 1000.000000
R31508 MemRCol1508 MemRCol1563 1000.000000
R31564 MemRCol1564 MemRCol1620 1000.000000
R31621 MemRCol1621 MemRCol1678 1000.000000
R31679 MemRCol1679 MemRCol1737 1000.000000
R31738 MemRCol1738 MemRCol1797 1000.000000
R31798 MemRCol1798 MemRCol1858 1000.000000
R31859 MemRCol1859 MemRCol1920 1000.000000
R31921 MemRCol1921 MemRCol1983 1000.000000
R31984 MemRCol1984 MemRCol2047 1000.000000
R32048 MemRCol2048 MemRCol2112 1000.000000
R3562 MemRCol562 MemRCol596 1000.000000
R3597 MemRCol597 MemRCol632 1000.000000
R3633 MemRCol633 MemRCol669 1000.000000
R3670 MemRCol670 MemRCol707 1000.000000
R3708 MemRCol708 MemRCol746 1000.000000
R3747 MemRCol747 MemRCol786 1000.000000
R3787 MemRCol787 MemRCol827 1000.000000
R3828 MemRCol828 MemRCol869 1000.000000
R3870 MemRCol870 MemRCol912 1000.000000
R3913 MemRCol913 MemRCol956 1000.000000
R3957 MemRCol957 MemRCol1001 1000.000000
R31002 MemRCol1002 MemRCol1047 1000.000000
R31048 MemRCol1048 MemRCol1094 1000.000000
R31095 MemRCol1095 MemRCol1142 1000.000000
R31143 MemRCol1143 MemRCol1191 1000.000000
R31192 MemRCol1192 MemRCol1241 1000.000000
R31242 MemRCol1242 MemRCol1292 1000.000000
R31293 MemRCol1293 MemRCol1344 1000.000000
R31345 MemRCol1345 MemRCol1397 1000.000000
R31398 MemRCol1398 MemRCol1451 1000.000000
R31452 MemRCol1452 MemRCol1506 1000.000000
R31507 MemRCol1507 MemRCol1562 1000.000000
R31563 MemRCol1563 MemRCol1619 1000.000000
R31620 MemRCol1620 MemRCol1677 1000.000000
R31678 MemRCol1678 MemRCol1736 1000.000000
R31737 MemRCol1737 MemRCol1796 1000.000000
R31797 MemRCol1797 MemRCol1857 1000.000000
R31858 MemRCol1858 MemRCol1919 1000.000000
R31920 MemRCol1920 MemRCol1982 1000.000000
R31983 MemRCol1983 MemRCol2046 1000.000000
R32047 MemRCol2047 MemRCol2111 1000.000000
R32112 MemRCol2112 MemRCol2177 1000.000000

*Column 'Ammeter' Resistances
R51 MemRCol596 ColC_1 0.000000001000
R52 MemRCol632 ColC_2 0.000000001000
R53 MemRCol669 ColC_3 0.000000001000
R54 MemRCol707 ColC_4 0.000000001000
R55 MemRCol746 ColC_5 0.000000001000
R56 MemRCol786 ColC_6 0.000000001000
R57 MemRCol827 ColC_7 0.000000001000
R58 MemRCol869 ColC_8 0.000000001000
R59 MemRCol912 ColC_9 0.000000001000
R510 MemRCol956 ColC_10 0.000000001000
R511 MemRCol1001 ColC_11 0.000000001000
R512 MemRCol1047 ColC_12 0.000000001000
R513 MemRCol1094 ColC_13 0.000000001000
R514 MemRCol1142 ColC_14 0.000000001000
R515 MemRCol1191 ColC_15 0.000000001000
R516 MemRCol1241 ColC_16 0.000000001000
R517 MemRCol1292 ColC_17 0.000000001000
R518 MemRCol1344 ColC_18 0.000000001000
R519 MemRCol1397 ColC_19 0.000000001000
R520 MemRCol1451 ColC_20 0.000000001000
R521 MemRCol1506 ColC_21 0.000000001000
R522 MemRCol1562 ColC_22 0.000000001000
R523 MemRCol1619 ColC_23 0.000000001000
R524 MemRCol1677 ColC_24 0.000000001000
R525 MemRCol1736 ColC_25 0.000000001000
R526 MemRCol1796 ColC_26 0.000000001000
R527 MemRCol1857 ColC_27 0.000000001000
R528 MemRCol1919 ColC_28 0.000000001000
R529 MemRCol1982 ColC_29 0.000000001000
R530 MemRCol2046 ColC_30 0.000000001000
R531 MemRCol2111 ColC_31 0.000000001000
R532 MemRCol2177 ColC_32 0.000000001000

*Column Voltage Sources
V2 ColC_1 0 0.000000
V5 ColC_2 0 0.000000
V9 ColC_3 0 0.000000
V14 ColC_4 0 0.000000
V20 ColC_5 0 0.000000
V27 ColC_6 0 0.000000
V35 ColC_7 0 0.000000
V44 ColC_8 0 0.000000
V54 ColC_9 0 0.000000
V65 ColC_10 0 0.000000
V77 ColC_11 0 0.000000
V90 ColC_12 0 0.000000
V104 ColC_13 0 0.000000
V119 ColC_14 0 0.000000
V135 ColC_15 0 0.000000
V152 ColC_16 0 0.000000
V170 ColC_17 0 0.000000
V189 ColC_18 0 0.000000
V209 ColC_19 0 0.000000
V230 ColC_20 0 0.000000
V252 ColC_21 0 0.000000
V275 ColC_22 0 0.000000
V299 ColC_23 0 0.000000
V324 ColC_24 0 0.000000
V350 ColC_25 0 0.000000
V377 ColC_26 0 0.000000
V405 ColC_27 0 0.000000
V434 ColC_28 0 0.000000
V464 ColC_29 0 0.000000
V495 ColC_30 0 0.000000
V527 ColC_31 0 0.000000
V560 ColC_32 0 0.000000

*Column Current Sources
I2 I_2 0 -0.000000
I5 I_5 0 -0.000000
I9 I_9 0 -0.000000
I14 I_14 0 -0.000000
I20 I_20 0 -0.000000
I27 I_27 0 -0.000000
I35 I_35 0 -0.000000
I44 I_44 0 -0.000000
I54 I_54 0 -0.000000
I65 I_65 0 -0.000000
I77 I_77 0 -0.000000
I90 I_90 0 -0.000000
I104 I_104 0 -0.000000
I119 I_119 0 -0.000000
I135 I_135 0 -0.000000
I152 I_152 0 -0.000000
I170 I_170 0 -0.000000
I189 I_189 0 -0.000000
I209 I_209 0 -0.000000
I230 I_230 0 -0.000000
I252 I_252 0 -0.000000
I275 I_275 0 -0.000000
I299 I_299 0 -0.000000
I324 I_324 0 -0.000000
I350 I_350 0 -0.000000
I377 I_377 0 -0.000000
I405 I_405 0 -0.000000
I434 I_434 0 -0.000000
I464 I_464 0 -0.000000
I495 I_495 0 -0.000000
I527 I_527 0 -0.000000
I560 I_560 0 -0.000000

*Spice Directives
.op
*.backanno
.end
